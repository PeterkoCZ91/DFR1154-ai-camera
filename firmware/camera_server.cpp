#include "camera_server.h"
#include "health_monitor.h"
#include "esp_http_server.h"
#include "ws_log.h"
#include "esp_camera.h"
#include "esp_timer.h"
#include "esp_task_wdt.h"
#include <WiFi.h>
#include <WiFiUdp.h>
#include "ArduinoJson.h"
#include "config.h"
#include "ir_control.h"
#include <freertos/FreeRTOS.h>
#include <freertos/semphr.h>
#ifdef INCLUDE_AUDIO
#include "audio_handler.h"
#endif
#include "motion_detection.h"
#ifdef INCLUDE_PERSON_DETECT
#include "person_detection.h"
#endif
#include "SD.h"
#include "SPI.h"
#include "FS.h"
#include <lwip/sockets.h> // Pro setsockopt (SO_SNDTIMEO)
#include "ESP32-RTSPServer.h"
#include "camera_capture.h"
#include "mbedtls/base64.h" // For Base64 decoding (HTTP Basic Auth)
#include <Update.h>          // HTTP OTA firmware update
#ifdef INCLUDE_SD_RECORDING
#include "avi_writer.h"      // AVI recording (MJPEG + PCM audio)
#endif
#include "board_config.h"    // I2S_SAMPLE_RATE

// ESP32-RTSPServer library (generic, works with any camera via esp_camera)
// #include "ESP32_RTSP.h"  // DISABLED - library not available

// Extern config from main.cpp
extern Config config;
extern bool saveConfig();
extern void saveCredentialsToNVS();
extern bool captive_portal_active;

httpd_handle_t camera_httpd = NULL;
httpd_handle_t stream_httpd = NULL;
httpd_handle_t audio_httpd = NULL;

// RTSP Server globals
RTSPServer rtspServer; // Global instance

// Recording Globals
bool is_recording = false;
File recordingFile;
SemaphoreHandle_t recordingMutex = NULL;
AviWriter aviWriter;
char lastRecordingFilename[64] = {0}; // Filled by startSDRecording, read by motionTask

// Forward declarations for recording functions
bool startSDRecording();
void stopSDRecording();

// UDP Remote Logging (debug only — build with -DUDP_LOG_IP=\"x.x.x.x\" to override)
WiFiUDP udpLog;
#ifndef UDP_LOG_IP
#define UDP_LOG_IP "127.0.0.1"
#endif
const char* RASPBERRY_PI_IP = UDP_LOG_IP;
const int UDP_LOG_PORT = 5000;
bool udp_logging_enabled = false;  // Disabled; never enable on untrusted networks
static SemaphoreHandle_t udp_mutex = NULL; // Mutex for thread-safe logging
static SemaphoreHandle_t settings_mutex = NULL; // Mutex for thread-safe settings access

// Send log over UDP to Raspberry Pi with error handling
void send_udp_log(const char* level, const char* message) {
    if (!udp_logging_enabled || WiFi.status() != WL_CONNECTED) {
        return;  // Skip if no WiFi or logging is off
    }

    // Mutex is created in startCameraServer(), skip if not ready yet
    if (udp_mutex == NULL) return;

    char log_message[512];
    unsigned long uptime_ms = millis();

    // Format: [ESP32][uptime][level] message
    int written = snprintf(log_message, sizeof(log_message), "[ESP32][%lu][%s] %s", uptime_ms, level, message);

    // Check buffer overflow
    if (written >= sizeof(log_message)) {
        Serial.println("⚠️ UDP log message truncated!");
        log_message[sizeof(log_message) - 1] = '\0';  // Ensure null termination
    }

    if (udp_mutex && xSemaphoreTake(udp_mutex, pdMS_TO_TICKS(10))) {
        udpLog.beginPacket(RASPBERRY_PI_IP, UDP_LOG_PORT);
        udpLog.write((const uint8_t*)log_message, strlen(log_message));

        // Check if packet was sent successfully
        if (!udpLog.endPacket()) {
            static unsigned long last_error_log = 0;
            if (millis() - last_error_log > 10000) {  // Log error max every 10s
                Serial.println("⚠️ Failed to send UDP log packet");
                last_error_log = millis();
            }
        }
        xSemaphoreGive(udp_mutex);
    }
}

// HTTP Basic Auth helper
// In LAB_MODE: always returns ESP_OK (no auth check)
// In production: validates Authorization header against config.http_user:config.http_pass
static esp_err_t check_basic_auth(httpd_req_t *req) {
#if LAB_MODE
    return ESP_OK;  // No auth in lab mode
#else
    char auth_header[256] = {0};
    esp_err_t err = httpd_req_get_hdr_value_str(req, "Authorization", auth_header, sizeof(auth_header));

    if (err != ESP_OK) {
        httpd_resp_set_status(req, "401 Unauthorized");
        httpd_resp_set_type(req, "text/plain");
        httpd_resp_set_hdr(req, "WWW-Authenticate", "Basic realm=\"ESP32-Cam\"");
        httpd_resp_send(req, "Authentication required", HTTPD_RESP_USE_STRLEN);
        return ESP_FAIL;
    }

    // Expect "Basic <base64>"
    if (strncmp(auth_header, "Basic ", 6) != 0) {
        httpd_resp_set_status(req, "401 Unauthorized");
        httpd_resp_set_type(req, "text/plain");
        httpd_resp_set_hdr(req, "WWW-Authenticate", "Basic realm=\"ESP32-Cam\"");
        httpd_resp_send(req, "Invalid auth scheme", HTTPD_RESP_USE_STRLEN);
        return ESP_FAIL;
    }

    const char* b64_creds = auth_header + 6;
    unsigned char decoded[128];
    size_t decoded_len = 0;
    int ret = mbedtls_base64_decode(decoded, sizeof(decoded) - 1, &decoded_len,
                                     (const unsigned char*)b64_creds, strlen(b64_creds));
    if (ret != 0) {
        httpd_resp_set_status(req, "401 Unauthorized");
        httpd_resp_set_type(req, "text/plain");
        httpd_resp_set_hdr(req, "WWW-Authenticate", "Basic realm=\"ESP32-Cam\"");
        httpd_resp_send(req, "Invalid credentials", HTTPD_RESP_USE_STRLEN);
        return ESP_FAIL;
    }
    decoded[decoded_len] = '\0';

    // Build expected "user:pass"
    String expected = config.http_user + ":" + config.http_pass;
    if (expected.equals((const char*)decoded)) {
        return ESP_OK;
    }

    httpd_resp_set_status(req, "401 Unauthorized");
    httpd_resp_set_type(req, "text/plain");
    httpd_resp_set_hdr(req, "WWW-Authenticate", "Basic realm=\"ESP32-Cam\"");
    httpd_resp_send(req, "Invalid credentials", HTTPD_RESP_USE_STRLEN);
    return ESP_FAIL;
#endif
}

// MJPEG stream boundary
#define PART_BOUNDARY "123456789000000000000987654321"
static const char* _STREAM_CONTENT_TYPE = "multipart/x-mixed-replace;boundary=" PART_BOUNDARY;
static const char* _STREAM_BOUNDARY = "\r\n--" PART_BOUNDARY "\r\n";
static const char* _STREAM_PART = "Content-Type: image/jpeg\r\nContent-Length: %u\r\n\r\n";

// HTML GUI — dark dashboard theme (auto-generated, do not edit manually)
// INDEX_HTML gzipped: 11645 -> 2943 bytes
const uint8_t INDEX_HTML_GZ[] PROGMEM = {
    0x1F, 0x8B, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xC5, 0x1A, 0x6B, 0x77, 0xDA, 0x38,
    0xF6, 0x7B, 0x7F, 0x85, 0xCB, 0x9C, 0x1E, 0xC3, 0x16, 0x3B, 0x06, 0x02, 0xA1, 0x0E, 0xD0, 0x99,
    0xB6, 0xE9, 0x6E, 0x67, 0xDA, 0x26, 0xA7, 0xC9, 0xCC, 0x9C, 0xF9, 0xC4, 0x11, 0x58, 0x06, 0x4D,
    0x8D, 0xE5, 0x23, 0x8B, 0x3C, 0x96, 0xE6, 0xBF, 0xEF, 0x95, 0x64, 0x40, 0xF2, 0x2B, 0x64, 0x9A,
    0x99, 0x4D, 0x9B, 0x16, 0x4B, 0x57, 0xF7, 0xFD, 0x94, 0x79, 0x36, 0x7A, 0xFE, 0xEE, 0xFC, 0xED,
    0xD5, 0x1F, 0x17, 0x67, 0xD6, 0x92, 0xAF, 0xA2, 0xC9, 0xB3, 0x91, 0xF8, 0xCF, 0x8A, 0x50, 0xBC,
    0x18, 0x37, 0x70, 0xDC, 0x10, 0x0B, 0x18, 0x05, 0x93, 0x67, 0x16, 0xFC, 0x8C, 0x56, 0x98, 0x23,
    0x6B, 0xBE, 0x44, 0x2C, 0xC5, 0x7C, 0xDC, 0xF8, 0xF5, 0xEA, 0xBD, 0x33, 0x6C, 0x64, 0x5B, 0x9C,
    0xF0, 0x08, 0x4F, 0xCE, 0x2E, 0x2F, 0x7A, 0x5D, 0xE7, 0xB2, 0x67, 0xBD, 0x45, 0x2B, 0xCC, 0xD0,
    0xE8, 0x48, 0x2D, 0x6B, 0xA7, 0x63, 0xD8, 0x18, 0x37, 0xAE, 0x09, 0xBE, 0x49, 0x28, 0xE3, 0x0D,
    0x6B, 0x4E, 0x63, 0x8E, 0x63, 0xC0, 0x76, 0x43, 0x02, 0xBE, 0x1C, 0x07, 0xF8, 0x9A, 0xCC, 0xB1,
    0x23, 0x1F, 0xDA, 0x16, 0x89, 0x09, 0x27, 0x28, 0x72, 0xD2, 0x39, 0x8A, 0xF0, 0xB8, 0xB3, 0xA5,
    0x95, 0xF2, 0xBB, 0x2D, 0x52, 0xF1, 0xF3, 0xAF, 0xCD, 0x0A, 0xB1, 0x05, 0x89, 0x7D, 0xEF, 0x34,
    0x41, 0x41, 0x40, 0xE2, 0x05, 0x7C, 0x9A, 0xD1, 0x5B, 0x27, 0x25, 0xFF, 0x15, 0x0F, 0x33, 0xCA,
    0x02, 0xCC, 0x1C, 0x58, 0xB9, 0xDF, 0x9D, 0x99, 0xD1, 0xE0, 0x6E, 0xB3, 0x7B, 0x12, 0x3F, 0x21,
    0x30, 0xE2, 0x84, 0x68, 0x45, 0xA2, 0x3B, 0xDF, 0xFE, 0x00, 0x4C, 0x31, 0xBB, 0x9D, 0xDE, 0xA5,
    0x1C, 0xAF, 0x9C, 0x35, 0x69, 0x3B, 0x28, 0x49, 0x22, 0xEC, 0xA8, 0x85, 0x76, 0x8A, 0xE2, 0xD4,
    0x49, 0x31, 0x23, 0xE1, 0xA9, 0x81, 0x63, 0x86, 0xE6, 0x5F, 0x17, 0x8C, 0xAE, 0xE3, 0xC0, 0xFF,
    0xC1, 0x0B, 0xBD, 0xB0, 0xDB, 0x33, 0xF7, 0xE7, 0x34, 0xA2, 0xCC, 0xFF, 0x01, 0x7B, 0xE2, 0x8F,
    0xB9, 0xB5, 0x22, 0xB1, 0xB3, 0xC4, 0x64, 0xB1, 0xE4, 0x7E, 0xC7, 0xF3, 0xAE, 0x97, 0xE6, 0x6E,
    0x40, 0xD2, 0x24, 0x42, 0x77, 0x7E, 0x18, 0xE1, 0x5B, 0x73, 0xE7, 0xCF, 0x75, 0xCA, 0x49, 0x78,
    0xE7, 0x64, 0x7A, 0xF4, 0xE7, 0x58, 0xB0, 0x6E, 0xC2, 0xA0, 0x88, 0x2C, 0x62, 0x87, 0x00, 0xE7,
    0xA9, 0xC4, 0xE0, 0xA4, 0x1C, 0x31, 0x6E, 0xC2, 0x6C, 0x35, 0xD7, 0x3D, 0x4E, 0x6E, 0xAD, 0xCE,
    0x20, 0xD1, 0xC8, 0xEC, 0xB5, 0xE6, 0x06, 0x28, 0x5D, 0x82, 0xB6, 0x6F, 0x95, 0x81, 0xFC, 0x93,
    0x81, 0x07, 0x80, 0xEA, 0x33, 0x70, 0xFD, 0x42, 0x83, 0x14, 0x5E, 0x83, 0xD9, 0x86, 0xE3, 0x5B,
    0xEE, 0x48, 0xFA, 0x5B, 0xCE, 0x94, 0xAD, 0xC0, 0x1A, 0x9C, 0xD3, 0x95, 0x24, 0x57, 0x38, 0x65,
    0x2D, 0x3B, 0x1B, 0x69, 0x0E, 0x30, 0x20, 0xF6, 0x3B, 0xEE, 0x00, 0xAF, 0x4E, 0xE5, 0xF3, 0x8D,
    0x52, 0xD0, 0x89, 0xE7, 0x9D, 0x66, 0xAA, 0x0C, 0xC3, 0xF0, 0x34, 0xC2, 0x1C, 0x10, 0x3B, 0x69,
    0x82, 0xE6, 0x42, 0x02, 0xC7, 0xF5, 0xBA, 0x78, 0xA5, 0x21, 0x05, 0x69, 0xF9, 0x3A, 0x75, 0x66,
    0x28, 0x58, 0xE0, 0x4D, 0xA9, 0x5A, 0x49, 0x1C, 0x91, 0x18, 0x3B, 0x52, 0xBB, 0xBA, 0xB2, 0x32,
    0x96, 0x17, 0x28, 0xF1, 0x0D, 0x8D, 0x48, 0x83, 0x29, 0x39, 0x38, 0x4D, 0xFC, 0x21, 0xEC, 0x6D,
    0xF5, 0x27, 0xD5, 0x77, 0x9C, 0x07, 0xD6, 0x1C, 0x83, 0x2D, 0x66, 0xA8, 0xE9, 0xB5, 0xBB, 0x9D,
    0x6E, 0xBB, 0xDB, 0xEF, 0xB7, 0xDD, 0x4E, 0xEB, 0x54, 0x39, 0xA8, 0xDF, 0x81, 0xA3, 0x29, 0x8D,
    0x48, 0x60, 0xE5, 0x61, 0xBA, 0xFD, 0x56, 0x0E, 0x9F, 0x72, 0x69, 0x86, 0x02, 0xB2, 0x4E, 0xFD,
    0xAE, 0xB0, 0xC2, 0x5E, 0x61, 0xEE, 0x10, 0xF4, 0x95, 0xE9, 0xC7, 0xF3, 0x82, 0xE3, 0x30, 0x2C,
    0xB5, 0x65, 0xA6, 0x96, 0x80, 0x72, 0x53, 0x29, 0xCA, 0x9C, 0x42, 0xA6, 0xCC, 0x1F, 0xC5, 0x47,
    0x93, 0x60, 0xDF, 0x7B, 0x91, 0xF3, 0xB0, 0x98, 0xAC, 0x10, 0x27, 0x34, 0xF6, 0x93, 0x75, 0x94,
    0x62, 0xAB, 0x9B, 0x42, 0xEC, 0x86, 0x22, 0x7C, 0x71, 0xB9, 0x1F, 0x51, 0xEE, 0xD0, 0xAF, 0x1B,
    0x3D, 0x5E, 0xBA, 0xDD, 0x79, 0xBF, 0x8F, 0x73, 0x30, 0x98, 0x31, 0x03, 0x08, 0x87, 0xC7, 0xF0,
    0x73, 0xBA, 0x27, 0x17, 0xD3, 0x58, 0x3B, 0xF3, 0xE3, 0x57, 0x7C, 0x17, 0x32, 0xC8, 0x30, 0xA9,
    0x25, 0xF9, 0xD8, 0x78, 0x2F, 0xDA, 0xC2, 0x2F, 0x37, 0x54, 0xF8, 0x06, 0xBF, 0xF3, 0x3B, 0xF7,
    0x7D, 0xED, 0xC9, 0x3D, 0xBE, 0xBF, 0x7F, 0xA6, 0x3B, 0x1F, 0xA3, 0x9B, 0x5A, 0xB3, 0x09, 0x63,
    0x6C, 0x7F, 0x5D, 0xEF, 0xB8, 0xD4, 0x28, 0x79, 0x33, 0x9A, 0x67, 0x86, 0xB5, 0x86, 0x94, 0x71,
    0xB7, 0x8B, 0x44, 0xD0, 0xBB, 0xD5, 0x2D, 0xB8, 0xD2, 0x43, 0x11, 0xD5, 0x19, 0x56, 0xC4, 0xAE,
    0x10, 0xCF, 0x5A, 0x76, 0x8D, 0xC8, 0xEA, 0xEC, 0x3D, 0x05, 0x79, 0xC8, 0x9B, 0x0D, 0x8D, 0x38,
    0xEB, 0x43, 0x9C, 0x99, 0xC8, 0x07, 0xB9, 0x68, 0x05, 0x8C, 0xC9, 0x26, 0x43, 0x30, 0xF0, 0x06,
    0xDE, 0xC9, 0xD0, 0xF0, 0xC3, 0x3E, 0xA0, 0x2F, 0x72, 0x67, 0xF8, 0x20, 0xC3, 0x68, 0xE5, 0xCC,
    0x78, 0x9C, 0x6E, 0x8C, 0x1C, 0x27, 0x42, 0xAE, 0x23, 0xDC, 0xBA, 0x22, 0xBF, 0xC9, 0x34, 0x76,
    0xC3, 0x00, 0x4A, 0xFC, 0xA3, 0x61, 0x04, 0x54, 0x8E, 0xC2, 0x5A, 0x1B, 0xEA, 0xB3, 0x88, 0xCE,
    0xBF, 0xEE, 0x54, 0xDD, 0xE9, 0x81, 0xAA, 0x7B, 0xDD, 0x9A, 0xA8, 0xDD, 0x06, 0xD2, 0x36, 0xAC,
    0x4A, 0x92, 0xBB, 0xA6, 0xD7, 0x5C, 0xBE, 0x1A, 0x78, 0x5E, 0xAD, 0xD5, 0x05, 0x61, 0x69, 0xD6,
    0x00, 0xCF, 0x29, 0xDB, 0x3B, 0x76, 0xCE, 0xF0, 0x0C, 0xAA, 0x0E, 0x91, 0x9B, 0x28, 0x8A, 0x2C,
    0xB7, 0x9B, 0xE6, 0x91, 0x42, 0x62, 0x5F, 0xA2, 0x80, 0xDE, 0xF8, 0x9E, 0xE5, 0x49, 0xCF, 0x29,
    0x26, 0x92, 0x56, 0xA9, 0x6B, 0xEC, 0x95, 0xE6, 0x2F, 0xE9, 0x35, 0x36, 0x63, 0xAE, 0xD7, 0x0B,
    0x44, 0x96, 0xCD, 0xA1, 0x17, 0xDA, 0x2A, 0xA0, 0xEF, 0x41, 0x9E, 0x92, 0x6C, 0x86, 0x94, 0xAD,
    0x7C, 0xF9, 0x29, 0x42, 0x1C, 0xFF, 0xD1, 0x74, 0x20, 0x28, 0x5A, 0x39, 0x82, 0x01, 0xE6, 0x78,
    0xCE, 0x9F, 0xD4, 0x4A, 0x92, 0x9F, 0xCE, 0x60, 0xD8, 0x1E, 0x42, 0xBC, 0x1D, 0x9F, 0x40, 0x72,
    0x05, 0x86, 0xB6, 0xFE, 0x3D, 0xEC, 0xF7, 0xC3, 0x93, 0xEF, 0x34, 0x59, 0x3E, 0xB8, 0x75, 0x5A,
    0xBD, 0xFA, 0x24, 0xFD, 0x04, 0x56, 0x2E, 0x55, 0x60, 0xD1, 0x62, 0x05, 0xCE, 0xA0, 0x7C, 0xE8,
    0x79, 0x0E, 0x32, 0x33, 0x75, 0x16, 0x8C, 0x04, 0xE5, 0xBA, 0x17, 0x3B, 0x26, 0x4F, 0x62, 0xC5,
    0x81, 0x82, 0x98, 0x08, 0x63, 0x42, 0x24, 0x46, 0xEB, 0x55, 0x9C, 0xFA, 0x0C, 0x27, 0x18, 0xF1,
    0x26, 0x5A, 0x73, 0xEA, 0x84, 0x84, 0xB7, 0xA1, 0x83, 0x81, 0xCE, 0xA0, 0xD9, 0x11, 0x61, 0xDB,
    0xEE, 0x84, 0xAC, 0x95, 0x53, 0x87, 0x08, 0x69, 0x91, 0x9B, 0x0E, 0x4C, 0x57, 0x92, 0xCB, 0x39,
    0x62, 0xC1, 0xDF, 0x9D, 0x92, 0x4F, 0x1E, 0x36, 0xDB, 0xCE, 0x03, 0x85, 0xD3, 0xCB, 0xB4, 0xF4,
    0x40, 0x4A, 0xAE, 0x15, 0xC8, 0x72, 0x23, 0x34, 0xC3, 0x91, 0x96, 0x88, 0xDD, 0x81, 0x56, 0xB2,
    0xB3, 0x3C, 0x2A, 0x91, 0xEE, 0x83, 0x69, 0x9D, 0x24, 0x98, 0xCD, 0x51, 0x8A, 0xF3, 0xED, 0x8E,
    0xEB, 0x15, 0xB3, 0x6C, 0xCF, 0x48, 0xB2, 0x1A, 0xE1, 0x6B, 0x14, 0xAD, 0xB1, 0x51, 0x01, 0xE4,
    0xE9, 0xBC, 0xE7, 0xEF, 0x9B, 0xAB, 0x1A, 0x34, 0xEE, 0x0D, 0x62, 0xF1, 0x36, 0xF9, 0x87, 0xFD,
    0x57, 0xD8, 0x9B, 0xD5, 0x41, 0x43, 0xFB, 0xB5, 0x05, 0x56, 0x55, 0x5C, 0x77, 0xC9, 0x14, 0x1C,
    0x19, 0x5C, 0xDE, 0x91, 0xE3, 0x82, 0xAE, 0x98, 0x93, 0xEF, 0x51, 0xCC, 0x70, 0xA7, 0x18, 0x59,
    0x59, 0x21, 0x6B, 0x69, 0x9D, 0x9A, 0x13, 0xE1, 0x90, 0xFB, 0xB2, 0xFD, 0xDC, 0xF3, 0x21, 0xAA,
    0x0C, 0xA3, 0x51, 0xFA, 0xF7, 0x44, 0xC6, 0xA0, 0x5F, 0x1F, 0x19, 0x65, 0x5E, 0x33, 0xE7, 0x2C,
    0x12, 0xF5, 0x71, 0x53, 0xDA, 0xAD, 0xEF, 0x1D, 0x32, 0xF3, 0x74, 0x99, 0x50, 0x72, 0x1E, 0x5C,
    0xF0, 0xD7, 0x7C, 0x89, 0xCE, 0xD7, 0xFC, 0xF9, 0x9A, 0xA5, 0xA0, 0xF0, 0x84, 0x92, 0xE2, 0x2C,
    0x51, 0x92, 0x9F, 0x1E, 0x4E, 0x6A, 0x46, 0x69, 0x2F, 0x69, 0xB0, 0x2B, 0x8A, 0x7C, 0x69, 0xDF,
    0x6D, 0xCE, 0x50, 0xF5, 0xE9, 0x60, 0xF0, 0x9D, 0x1D, 0x5A, 0x89, 0x1D, 0x2A, 0xD2, 0xAD, 0x81,
    0x63, 0xD7, 0xD2, 0x3B, 0x8A, 0xD9, 0x12, 0x88, 0x7E, 0xAB, 0x04, 0xB7, 0x4B, 0xE3, 0x02, 0xE2,
    0xDE, 0x71, 0xBB, 0xF3, 0xEA, 0xA4, 0xFD, 0xEA, 0x58, 0x15, 0xB3, 0x22, 0x5E, 0x0D, 0xA0, 0xB7,
    0xAF, 0x76, 0x85, 0x6E, 0x7A, 0x47, 0x03, 0x91, 0xCD, 0x43, 0x15, 0xB3, 0x48, 0x24, 0x5F, 0xE7,
    0x8C, 0x9A, 0x5A, 0x46, 0x85, 0xE1, 0x79, 0x51, 0x47, 0xBD, 0x57, 0x6D, 0xC0, 0x03, 0x7F, 0x2B,
    0xA8, 0x68, 0x00, 0x1A, 0x91, 0x6D, 0xB6, 0x28, 0x12, 0x49, 0x18, 0x8C, 0x01, 0xEC, 0x6E, 0x73,
    0xC8, 0x74, 0xA5, 0xD3, 0x31, 0x1B, 0x22, 0x63, 0x52, 0xAA, 0x21, 0x53, 0x61, 0x79, 0x9D, 0xD8,
    0xB0, 0xD4, 0xAA, 0x84, 0x39, 0x25, 0x86, 0xED, 0xF6, 0x3B, 0x60, 0xB8, 0x4E, 0xBB, 0x37, 0xA8,
    0x54, 0x87, 0x06, 0xA1, 0xE9, 0x23, 0x9C, 0xCD, 0xC2, 0xAE, 0x9E, 0x3D, 0x7F, 0x5C, 0xE1, 0x80,
    0xA0, 0xE6, 0x7E, 0x2C, 0x87, 0x14, 0x0E, 0xED, 0x96, 0x99, 0x31, 0x2A, 0x46, 0xEB, 0x9E, 0x3E,
    0x29, 0x9B, 0x29, 0xB0, 0x3C, 0xB7, 0x41, 0xFA, 0xB2, 0xE0, 0x37, 0x77, 0x68, 0xDF, 0x52, 0xD4,
    0x66, 0xC4, 0x9E, 0xCC, 0x7E, 0xB9, 0xB3, 0xFA, 0x0C, 0x20, 0xDB, 0xFA, 0x80, 0x30, 0x55, 0x0E,
    0x7C, 0x75, 0xBC, 0x24, 0x63, 0xDC, 0xE7, 0x42, 0x74, 0x74, 0x94, 0xDD, 0x09, 0x8D, 0x8E, 0xD4,
    0x75, 0xD5, 0x48, 0x5C, 0xF0, 0x64, 0xD7, 0x45, 0x01, 0xB9, 0xB6, 0xE6, 0x11, 0x4A, 0xD3, 0x71,
    0x43, 0xDC, 0x5F, 0x34, 0xF6, 0x37, 0x47, 0xFA, 0x96, 0xD2, 0x8F, 0xB6, 0x29, 0x01, 0x96, 0x9D,
    0xFD, 0x9D, 0xD6, 0x4F, 0x1F, 0x76, 0xD7, 0x5A, 0xB0, 0x6C, 0xC2, 0x69, 0x88, 0xF4, 0xEB, 0x86,
    0xC6, 0x64, 0x04, 0xE5, 0x28, 0xCE, 0x6D, 0xC1, 0x64, 0x6B, 0xA9, 0x09, 0xB8, 0x61, 0x91, 0x00,
    0xB8, 0xA2, 0x1C, 0x00, 0x8F, 0x04, 0xE4, 0xC4, 0x52, 0x07, 0xC4, 0x32, 0x58, 0x02, 0x2A, 0x22,
    0x24, 0xD7, 0xC6, 0xE4, 0x2D, 0x7C, 0x04, 0x9D, 0xE0, 0x20, 0x83, 0x1A, 0x1D, 0x01, 0x41, 0x4D,
    0x0E, 0xF5, 0x58, 0x21, 0x17, 0xA3, 0x05, 0xA9, 0xBA, 0x93, 0xDF, 0x48, 0x80, 0xA9, 0xA5, 0x74,
    0x0F, 0xF2, 0x74, 0x73, 0x10, 0xC9, 0xE4, 0xD3, 0xCF, 0x17, 0x67, 0xFF, 0xCE, 0x00, 0xAC, 0x90,
    0xD1, 0x95, 0x75, 0xFE, 0x5B, 0x6F, 0x30, 0xF0, 0xAC, 0x79, 0xA6, 0x83, 0xA4, 0x4E, 0x05, 0x3B,
    0x93, 0xE6, 0x48, 0x4B, 0x48, 0x64, 0x2D, 0x19, 0x0E, 0xC7, 0x8D, 0x23, 0x05, 0xA7, 0x94, 0x90,
    0x9D, 0x81, 0xBE, 0x1F, 0xB4, 0x92, 0xE1, 0xD9, 0xCF, 0x25, 0x0D, 0x8B, 0x43, 0x21, 0x17, 0xB7,
    0x8E, 0xD3, 0x59, 0x84, 0x00, 0x64, 0x72, 0x99, 0xB1, 0x8E, 0xEA, 0x08, 0xA8, 0x16, 0x59, 0x74,
    0x16, 0x3A, 0x29, 0xB5, 0x5A, 0x24, 0xA5, 0xD6, 0x8B, 0xA4, 0xDE, 0x6D, 0xB1, 0xEC, 0xF4, 0x95,
    0x23, 0xFA, 0x08, 0x73, 0xEC, 0x22, 0x45, 0xB1, 0x22, 0x1E, 0x1B, 0xD5, 0x8A, 0xDC, 0x75, 0x51,
    0xE0, 0x1F, 0xDA, 0xB2, 0xEC, 0x1F, 0x1B, 0x93, 0x0F, 0x17, 0x8A, 0x92, 0xBE, 0x25, 0x9B, 0xAD,
    0x0C, 0x77, 0xD2, 0x98, 0xB8, 0xAE, 0x9B, 0xC1, 0x98, 0x2C, 0x3E, 0x8E, 0xD0, 0xAF, 0x09, 0x27,
    0x2B, 0x5C, 0x4B, 0x6C, 0x2D, 0x41, 0x1A, 0x13, 0xC7, 0x79, 0x02, 0x7A, 0x5F, 0x7E, 0xFA, 0x54,
    0x4B, 0x0C, 0x62, 0x35, 0x79, 0x22, 0x52, 0x17, 0x97, 0x0F, 0x11, 0x4B, 0x52, 0x06, 0x8E, 0xF3,
    0x34, 0xD4, 0x7E, 0x27, 0xEF, 0x49, 0x2D, 0x31, 0x96, 0xA6, 0xE4, 0x89, 0x68, 0x7D, 0x5C, 0xDF,
    0xD6, 0x92, 0x8A, 0xD6, 0xB7, 0x4F, 0xA5, 0x43, 0x46, 0x43, 0x12, 0xD5, 0xFB, 0x47, 0xA2, 0x60,
    0x9E, 0x88, 0xE2, 0xFB, 0xDF, 0x6B, 0x89, 0x41, 0x9D, 0x4E, 0x21, 0x5C, 0x2B, 0x89, 0xD5, 0x05,
    0xA8, 0x31, 0x8A, 0x68, 0xB1, 0x9F, 0x47, 0xA1, 0x1D, 0xD9, 0x96, 0xCC, 0x7C, 0x20, 0xCF, 0xD6,
    0x30, 0x8D, 0xA9, 0x5C, 0xBE, 0xA2, 0x0A, 0x29, 0x5D, 0x2C, 0x00, 0xEB, 0xEE, 0x60, 0xD6, 0x22,
    0x34, 0x2C, 0x1A, 0xCF, 0x23, 0x32, 0xFF, 0x3A, 0x6E, 0x28, 0x88, 0x4F, 0x12, 0xBC, 0xD9, 0x02,
    0xDD, 0x2E, 0x29, 0xA7, 0xBE, 0x25, 0x04, 0x51, 0xE8, 0xAA, 0x69, 0xC0, 0x1C, 0x94, 0x3E, 0x82,
    0xC6, 0x85, 0x04, 0x97, 0x34, 0xE4, 0x27, 0xA8, 0x6F, 0x87, 0xD1, 0x61, 0xA2, 0xD5, 0x0F, 0x0E,
    0xA6, 0xF3, 0x45, 0x82, 0x0B, 0x3A, 0xEA, 0x93, 0x98, 0x5B, 0x0E, 0xA2, 0x03, 0x7D, 0xD3, 0xA1,
    0x34, 0x3E, 0x7C, 0x11, 0xF8, 0x3F, 0x7C, 0xB1, 0x3E, 0x9E, 0xBD, 0x2B, 0x47, 0xFE, 0x08, 0x93,
    0x5F, 0x51, 0xB0, 0xE5, 0x5F, 0x30, 0xF7, 0xAE, 0xEA, 0xC8, 0x2B, 0xE8, 0x02, 0xD3, 0x56, 0xD6,
    0x47, 0x96, 0x94, 0xB2, 0x18, 0x25, 0x29, 0xD8, 0xB9, 0x58, 0x57, 0xF6, 0x95, 0x12, 0x66, 0x5B,
    0x50, 0x5C, 0xEA, 0x24, 0x68, 0x51, 0x83, 0x7A, 0x72, 0x99, 0xC1, 0xD5, 0xA0, 0x8A, 0xE8, 0xC2,
    0x11, 0xEF, 0xDF, 0xA0, 0xD9, 0x39, 0x9C, 0xC5, 0x8F, 0xE4, 0x1A, 0x5B, 0x1F, 0xE9, 0xA2, 0x8E,
    0xC5, 0x00, 0x2A, 0x6A, 0xCA, 0x4B, 0x8C, 0x55, 0x90, 0xF7, 0x9D, 0x25, 0x72, 0x41, 0x1D, 0x93,
    0xAA, 0x53, 0x3A, 0x04, 0x97, 0x04, 0xB4, 0x7E, 0xBE, 0x3C, 0xFF, 0x5C, 0x83, 0x0E, 0x0A, 0x46,
    0xC4, 0x97, 0x07, 0xA0, 0xFB, 0x8F, 0x04, 0xAC, 0xC1, 0x94, 0x05, 0x72, 0x80, 0x67, 0xEB, 0xC5,
    0x01, 0xF8, 0x54, 0x20, 0x5B, 0x12, 0xBC, 0x06, 0x2B, 0xC7, 0x11, 0x5E, 0x61, 0x2E, 0x34, 0xFF,
    0x20, 0xCA, 0xAB, 0x2D, 0xAC, 0x81, 0x4F, 0xF3, 0x57, 0xDD, 0xD5, 0x47, 0xE9, 0x9C, 0x91, 0x84,
    0xEF, 0xE1, 0x22, 0xCC, 0x2D, 0x25, 0xC3, 0x59, 0x8C, 0x66, 0x11, 0x0E, 0xC6, 0x21, 0x8A, 0x52,
    0xDC, 0xB6, 0x54, 0xF6, 0xC8, 0x2D, 0x12, 0x26, 0xF4, 0x8B, 0xB7, 0x8F, 0x6C, 0x1B, 0xC0, 0x6A,
    0xE1, 0x74, 0x1F, 0x4E, 0xE1, 0x3A, 0x56, 0x1D, 0xD2, 0x3A, 0x09, 0xE0, 0x80, 0xB2, 0x4A, 0x33,
    0x37, 0x83, 0x84, 0x98, 0xCF, 0x97, 0x4D, 0x3B, 0x33, 0xAE, 0xDD, 0x72, 0xF9, 0x12, 0xC7, 0x4D,
    0x36, 0x9E, 0x30, 0xF7, 0x4F, 0x99, 0x8A, 0xB2, 0x95, 0x60, 0x3C, 0xD9, 0x14, 0x9A, 0xBA, 0x80,
    0xCE, 0xD7, 0x2B, 0x68, 0xFE, 0x5D, 0x50, 0xC6, 0x99, 0xD0, 0x40, 0xCC, 0xDF, 0xDC, 0x7D, 0x08,
    0x9A, 0x36, 0x49, 0x04, 0x26, 0x68, 0x93, 0xDF, 0x66, 0xAF, 0x92, 0x03, 0x97, 0x24, 0xDF, 0xBE,
    0xD9, 0xAF, 0xED, 0xD3, 0xC3, 0x91, 0xA8, 0xF6, 0xA5, 0x80, 0x48, 0x2D, 0x03, 0x32, 0xC7, 0x29,
    0xC1, 0x26, 0x74, 0x29, 0x5A, 0x91, 0x5F, 0xDE, 0x8C, 0x3F, 0x21, 0xBE, 0x74, 0xC3, 0x88, 0x52,
    0xD6, 0x6C, 0x06, 0x6E, 0xC8, 0x30, 0x9E, 0x8A, 0x9D, 0x6F, 0xDF, 0xBC, 0xD6, 0x51, 0xC7, 0xEB,
    0xE6, 0xEF, 0x25, 0xF5, 0xD3, 0x67, 0xD1, 0xB8, 0x92, 0x2D, 0xB1, 0x6F, 0x97, 0x9C, 0x55, 0xE7,
    0x0C, 0x66, 0x15, 0x23, 0x2F, 0x6D, 0xEB, 0x97, 0x37, 0x76, 0xE5, 0x01, 0xE9, 0x5C, 0x9F, 0xC5,
    0x2B, 0x78, 0x5B, 0x96, 0x4B, 0xFB, 0x65, 0x53, 0x9D, 0x1B, 0xF5, 0xBD, 0xD7, 0xB6, 0x05, 0x33,
    0x8B, 0xED, 0x67, 0x0B, 0x1D, 0x4F, 0xAC, 0x88, 0x3B, 0x3E, 0xDB, 0xB7, 0xCB, 0x78, 0xA8, 0x64,
    0x5A, 0x36, 0x4C, 0x39, 0x55, 0x96, 0xE8, 0x47, 0x82, 0xED, 0x14, 0xA4, 0xB4, 0x04, 0xEC, 0x7F,
    0x7A, 0xF3, 0x18, 0xBB, 0x65, 0x95, 0xBE, 0x60, 0xB8, 0x6C, 0x3D, 0x73, 0x83, 0x52, 0xDD, 0x8B,
    0x56, 0x0B, 0x20, 0x6F, 0x48, 0x48, 0xA6, 0xE2, 0x33, 0xB0, 0x72, 0x5A, 0x09, 0x58, 0x67, 0x24,
    0xB1, 0x5F, 0xA6, 0x20, 0x75, 0xCE, 0x60, 0x4C, 0x2C, 0x81, 0x8C, 0xC1, 0x9B, 0x95, 0x5D, 0x09,
    0x5F, 0x62, 0x23, 0xB1, 0x33, 0x72, 0x86, 0x3B, 0x13, 0xA9, 0xE7, 0x41, 0xDF, 0x34, 0x50, 0x01,
    0x21, 0x09, 0x41, 0xD7, 0x68, 0x35, 0x23, 0x40, 0x7A, 0x1A, 0x89, 0xEB, 0xBD, 0x29, 0x34, 0x7D,
    0xCF, 0xC7, 0xE3, 0x75, 0x1C, 0xE0, 0x90, 0xC4, 0x38, 0x68, 0x15, 0xE3, 0xAC, 0x56, 0xDD, 0x70,
    0xBC, 0xA0, 0xEA, 0x02, 0x01, 0x97, 0xD3, 0xF7, 0xE4, 0x16, 0x07, 0xCD, 0x4E, 0x89, 0x52, 0xEE,
    0xCB, 0xB9, 0x54, 0x43, 0xE5, 0x34, 0xEB, 0x12, 0x5B, 0x35, 0xCE, 0xA5, 0x20, 0x0A, 0x5C, 0x98,
    0x08, 0x4A, 0x94, 0x61, 0x26, 0xBD, 0xE7, 0xCF, 0x03, 0x57, 0xAD, 0x4C, 0x45, 0xEE, 0x5D, 0x80,
    0x2B, 0x4E, 0x13, 0xD1, 0x6A, 0x95, 0xBB, 0xC0, 0x6A, 0x56, 0x6D, 0x7E, 0xA3, 0xB5, 0x2B, 0xF3,
    0x83, 0xD5, 0xCC, 0xE0, 0xD5, 0xCE, 0x5A, 0x3A, 0xB0, 0xAB, 0xC1, 0xD3, 0x6B, 0xFB, 0xFC, 0x33,
    0x58, 0xF2, 0xFC, 0xFD, 0xFB, 0x0A, 0x24, 0x9A, 0x63, 0x6C, 0xAB, 0x43, 0x11, 0x07, 0x74, 0x46,
    0x55, 0xEE, 0x60, 0x66, 0x78, 0xA1, 0x01, 0xB5, 0x32, 0xDD, 0x4D, 0xC9, 0x53, 0xAC, 0x36, 0xCB,
    0x95, 0x90, 0xD4, 0x28, 0xC1, 0xE8, 0x3D, 0xCB, 0xF8, 0x4F, 0xF2, 0x4A, 0xD8, 0xF7, 0x9C, 0x20,
    0x84, 0xC1, 0x5A, 0xBD, 0x22, 0x92, 0x2A, 0x45, 0xE4, 0x70, 0x58, 0x88, 0x54, 0x29, 0x62, 0x5F,
    0xC6, 0x84, 0x12, 0x48, 0x3A, 0xDD, 0x2D, 0x54, 0x24, 0x80, 0x1A, 0xC1, 0x8D, 0x66, 0xB8, 0x34,
    0x0B, 0xE4, 0x04, 0xD7, 0x9A, 0x60, 0x11, 0xD9, 0xDB, 0xA7, 0xD7, 0xF6, 0x97, 0xB3, 0xB7, 0xD5,
    0x52, 0xB3, 0x2A, 0xA9, 0x35, 0x04, 0x42, 0xAE, 0x2A, 0x91, 0x2B, 0xF9, 0x0F, 0x28, 0x87, 0x58,
    0xD2, 0x70, 0x17, 0xEE, 0xA8, 0x1E, 0x93, 0x8E, 0x77, 0x57, 0x56, 0xB9, 0xF8, 0xB4, 0x77, 0x17,
    0x58, 0x39, 0x6C, 0xF7, 0x40, 0x1B, 0x89, 0xAE, 0xA0, 0xD9, 0x7A, 0x54, 0xD1, 0x7F, 0x88, 0x6D,
    0xCC, 0xD8, 0x93, 0xF0, 0x7D, 0x1E, 0x86, 0xE2, 0x4D, 0x74, 0x81, 0xEB, 0x9C, 0x8A, 0xB7, 0x9D,
    0x0D, 0x8C, 0x2C, 0x7F, 0xA9, 0xB9, 0xD9, 0xF6, 0x59, 0xD2, 0x1F, 0xD9, 0x14, 0x1C, 0x78, 0x2A,
    0xF0, 0xE0, 0x72, 0x7F, 0x24, 0x35, 0xFE, 0xB8, 0x1B, 0x9A, 0xCA, 0xBC, 0x88, 0xE4, 0x7C, 0x71,
    0x3B, 0x30, 0x81, 0x1F, 0x65, 0x1C, 0xD4, 0xC7, 0x1E, 0xA9, 0xF2, 0xC2, 0xDD, 0x69, 0x4B, 0x5E,
    0x76, 0x97, 0x74, 0x0C, 0xA6, 0xA1, 0xEF, 0x8D, 0x97, 0x2C, 0xC5, 0x2E, 0xD2, 0x9C, 0x82, 0x2B,
    0xBA, 0xC8, 0x6C, 0xD4, 0xB1, 0xDB, 0x1B, 0x68, 0x87, 0x97, 0x34, 0xF0, 0xED, 0x8B, 0xF3, 0xCB,
    0x2B, 0xBB, 0xAD, 0x6E, 0x72, 0x53, 0x7F, 0x63, 0x67, 0x82, 0x3A, 0x57, 0x77, 0x09, 0x06, 0x9E,
    0xC4, 0x77, 0xF8, 0xC8, 0x5C, 0xBE, 0xA4, 0x3A, 0x12, 0x36, 0xB1, 0xEF, 0xDB, 0x05, 0x11, 0xC5,
    0xBD, 0xB1, 0x2F, 0xA6, 0x09, 0x71, 0x2F, 0x0D, 0xE8, 0x49, 0x78, 0xD7, 0xDC, 0x94, 0x56, 0x0A,
    0xFF, 0xB9, 0x91, 0x7A, 0xEF, 0x5B, 0xF7, 0x99, 0x85, 0x85, 0x84, 0x66, 0x1B, 0x5C, 0xFA, 0x4A,
    0x29, 0x27, 0xEC, 0x76, 0x1C, 0xFF, 0xBF, 0x0B, 0x5B, 0x55, 0x14, 0xFC, 0xE7, 0x46, 0x86, 0xFD,
    0x5E, 0x79, 0xB7, 0xD7, 0x02, 0xE5, 0xF2, 0xAA, 0xB4, 0xF6, 0x0F, 0x48, 0x8B, 0xD4, 0x9B, 0x06,
    0x2D, 0x8D, 0xA6, 0x9C, 0x26, 0x80, 0x51, 0x7E, 0x47, 0xD2, 0x36, 0xA5, 0x04, 0x2B, 0x5C, 0xC1,
    0x3C, 0x40, 0xD7, 0xBC, 0xA9, 0x0B, 0xDC, 0xEE, 0x7B, 0xDE, 0x41, 0x32, 0x8B, 0x6B, 0x8A, 0x4D,
    0x55, 0xE2, 0xC8, 0xAE, 0x15, 0xFE, 0x09, 0x99, 0xD7, 0x9C, 0x4E, 0x57, 0x34, 0xC0, 0xBE, 0x9A,
    0xEB, 0x64, 0xAA, 0xF1, 0x77, 0x31, 0x4C, 0xC3, 0x10, 0xB0, 0x0B, 0x7C, 0x07, 0x09, 0xDF, 0xCB,
    0x0B, 0xBF, 0xFB, 0x68, 0x3A, 0xC5, 0x1E, 0x04, 0x30, 0xC9, 0x2F, 0xD8, 0x42, 0x7B, 0x5B, 0x40,
    0xE5, 0x69, 0x70, 0x72, 0x42, 0x1A, 0xDF, 0x90, 0x38, 0xA0, 0x37, 0x6E, 0x44, 0x95, 0xA8, 0xEE,
    0x92, 0xA6, 0x5C, 0x7C, 0x8B, 0x78, 0x0F, 0x57, 0x99, 0x0C, 0xB5, 0x77, 0x0A, 0x90, 0x90, 0xE5,
    0xAC, 0x6D, 0x2F, 0x39, 0x4F, 0xFC, 0xA3, 0x23, 0xFB, 0xE5, 0xF2, 0xA5, 0xED, 0x0F, 0x3B, 0xD9,
    0x3B, 0x08, 0xFB, 0x00, 0x6C, 0xDA, 0x6B, 0x83, 0x4A, 0x6C, 0xF9, 0x17, 0x0E, 0x19, 0xDE, 0xD1,
    0xD1, 0x76, 0x0E, 0x1F, 0x1D, 0xA9, 0x37, 0x53, 0xA3, 0x23, 0xF5, 0x7D, 0xEB, 0xFF, 0x01, 0x87,
    0x78, 0xA2, 0x81, 0x81, 0x2D, 0x00, 0x00
};
const size_t INDEX_HTML_GZ_LEN = sizeof(INDEX_HTML_GZ);

// Stranka nastaveni — dark dashboard theme
// SETTINGS_HTML gzipped: 25952 -> 5023 bytes
const uint8_t SETTINGS_HTML_GZ[] PROGMEM = {
    0x1F, 0x8B, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xCD, 0x3D, 0x69, 0x77, 0xDB, 0xB8,
    0xB5, 0xDF, 0xF3, 0x2B, 0x30, 0xCA, 0xC9, 0x50, 0x9A, 0x11, 0x25, 0x8A, 0x5A, 0x22, 0x4B, 0x96,
    0xFA, 0x12, 0xC7, 0x99, 0xA6, 0x67, 0xD2, 0xA4, 0x75, 0xDA, 0xD7, 0xBE, 0x39, 0x73, 0x7C, 0x20,
    0x12, 0x92, 0x38, 0xA6, 0x48, 0x95, 0xA4, 0xBC, 0xC4, 0xF5, 0x7F, 0x7F, 0x17, 0x00, 0x41, 0x82,
    0x24, 0x28, 0x91, 0x5E, 0x12, 0x3B, 0x1B, 0x17, 0xE0, 0xEE, 0x2B, 0x00, 0x29, 0x2F, 0x8E, 0x7F,
    0x78, 0xF7, 0xE9, 0xE4, 0xCB, 0xBF, 0x3F, 0x9F, 0xA2, 0x75, 0xB4, 0x71, 0xE7, 0x2F, 0x8E, 0xE9,
    0x3F, 0xC8, 0xC5, 0xDE, 0x6A, 0xD6, 0x20, 0x5E, 0x83, 0x3E, 0x20, 0xD8, 0x9E, 0xBF, 0x40, 0xF0,
    0x73, 0xBC, 0x21, 0x11, 0x46, 0xD6, 0x1A, 0x07, 0x21, 0x89, 0x66, 0x8D, 0x7F, 0x7C, 0x79, 0xAF,
    0x8F, 0x1B, 0xF1, 0xAB, 0xC8, 0x89, 0x5C, 0x32, 0x3F, 0xC1, 0x1B, 0x12, 0x60, 0x04, 0xAF, 0x23,
    0xC7, 0x5B, 0x85, 0xC7, 0x5D, 0xFE, 0x58, 0x9A, 0xED, 0xC1, 0x88, 0x59, 0xE3, 0xD2, 0x21, 0x57,
    0x5B, 0x3F, 0x88, 0x1A, 0xC8, 0xF2, 0xBD, 0x88, 0x78, 0x00, 0xED, 0xCA, 0xB1, 0xA3, 0xF5, 0xCC,
    0x26, 0x97, 0x8E, 0x45, 0x74, 0x76, 0xD3, 0x46, 0x8E, 0xE7, 0x44, 0x0E, 0x76, 0xF5, 0xD0, 0xC2,
    0x2E, 0x99, 0xF5, 0x04, 0xAE, 0x30, 0xBA, 0x11, 0x40, 0xE9, 0xCF, 0x4F, 0xB7, 0x1B, 0x1C, 0xAC,
    0x1C, 0x6F, 0x62, 0x4C, 0xB7, 0xD8, 0xB6, 0x01, 0x31, 0x5C, 0x2D, 0xFC, 0x6B, 0x3D, 0x74, 0xBE,
    0xD2, 0x9B, 0x85, 0x1F, 0xD8, 0x24, 0xD0, 0xE1, 0xC9, 0x5D, 0x32, 0x67, 0xE1, 0xDB, 0x37, 0xB7,
    0xC9, 0x1D, 0xFD, 0x59, 0x02, 0x21, 0xFA, 0x12, 0x6F, 0x1C, 0xF7, 0x66, 0xA2, 0x7D, 0x00, 0xA2,
    0x02, 0xAD, 0x1D, 0xDE, 0x84, 0x11, 0xD9, 0xE8, 0x3B, 0xA7, 0xAD, 0xE3, 0xED, 0xD6, 0x25, 0x3A,
    0x7F, 0xD0, 0x0E, 0xB1, 0x17, 0xEA, 0x21, 0x09, 0x9C, 0xE5, 0x34, 0x03, 0x63, 0x81, 0xAD, 0x8B,
    0x55, 0xE0, 0xEF, 0x3C, 0x7B, 0xF2, 0xD2, 0x58, 0x1A, 0x4B, 0xB3, 0x3F, 0xB5, 0x7C, 0xD7, 0x0F,
    0x26, 0x2F, 0x89, 0x41, 0x7F, 0x65, 0x47, 0x6F, 0x1C, 0x4F, 0x5F, 0x13, 0x67, 0xB5, 0x8E, 0x26,
    0x3D, 0xC3, 0xB8, 0x5C, 0x27, 0xD4, 0x9B, 0x83, 0xED, 0x35, 0xEA, 0x8D, 0xE8, 0x5F, 0x86, 0xB1,
    0xBD, 0x4E, 0x67, 0xA5, 0xF4, 0x77, 0xAE, 0x02, 0xBC, 0x05, 0xBE, 0xAF, 0xB9, 0xA8, 0x26, 0x23,
    0x36, 0x50, 0xC8, 0x01, 0xE1, 0x5D, 0xE4, 0xDF, 0xBD, 0x48, 0x46, 0x77, 0x7F, 0x42, 0x7F, 0x06,
    0x2D, 0x92, 0x00, 0xFD, 0xD4, 0x4D, 0x41, 0x6C, 0x57, 0xFA, 0x9A, 0x3D, 0xBD, 0xB5, 0x9D, 0x70,
    0xEB, 0xE2, 0x9B, 0xC9, 0xD2, 0x25, 0xD7, 0x53, 0xEC, 0x3A, 0x2B, 0x4F, 0x77, 0x80, 0xCF, 0x70,
    0x62, 0x11, 0x2A, 0x88, 0xE9, 0x1F, 0xBB, 0x30, 0x72, 0x96, 0x37, 0x7A, 0xAC, 0xAC, 0x49, 0xB8,
    0xC5, 0xA0, 0xA4, 0x05, 0x89, 0xAE, 0x08, 0xF1, 0x62, 0xAC, 0x20, 0xDF, 0x28, 0xF2, 0x37, 0x8C,
    0xF8, 0x3B, 0x05, 0x12, 0xB4, 0xEE, 0xDD, 0x32, 0x19, 0x83, 0x56, 0xC8, 0xA4, 0xD7, 0xE9, 0x93,
    0xCD, 0x94, 0xDD, 0x5F, 0x71, 0x11, 0xBC, 0x36, 0x0C, 0x21, 0xAC, 0xE5, 0x72, 0x29, 0x41, 0xA0,
    0x42, 0xD5, 0x5D, 0xC7, 0xBB, 0xC8, 0xEA, 0x2B, 0x1E, 0x6B, 0x18, 0xF6, 0x60, 0xB9, 0x9C, 0x46,
    0xE4, 0x3A, 0xD2, 0x6D, 0x62, 0xF9, 0x01, 0x8E, 0x1C, 0xDF, 0x9B, 0x78, 0xBE, 0x47, 0xA6, 0x29,
    0xBA, 0xCE, 0x78, 0x08, 0xE8, 0x32, 0xF3, 0x85, 0xB0, 0x99, 0x98, 0x81, 0xE6, 0x29, 0x37, 0x93,
    0x49, 0x0F, 0xEE, 0x43, 0xDF, 0x75, 0x6C, 0x14, 0xAC, 0x16, 0xB8, 0x69, 0xB4, 0xCD, 0x9E, 0xD9,
    0x36, 0x87, 0xC3, 0x76, 0xC7, 0x1C, 0xB6, 0xE2, 0x41, 0x7A, 0x80, 0x6D, 0x67, 0x17, 0x4E, 0xC6,
    0xB2, 0x72, 0xE8, 0x4F, 0x14, 0x80, 0x65, 0x38, 0x8C, 0x02, 0xEC, 0xBA, 0xA8, 0x63, 0x86, 0x4A,
    0xE5, 0x25, 0x2C, 0x4D, 0xD6, 0xFE, 0x25, 0xC8, 0x5F, 0xB2, 0x9B, 0x3C, 0xD2, 0x5E, 0x2B, 0xAB,
    0xC7, 0x13, 0xDF, 0x75, 0xF1, 0x36, 0x74, 0x16, 0x2E, 0x01, 0x37, 0xB3, 0x28, 0xAA, 0x50, 0xD6,
    0xAA, 0x0D, 0x4E, 0xE6, 0xB8, 0xE1, 0x6D, 0x99, 0x5D, 0x32, 0xF8, 0x14, 0xB2, 0xF8, 0xD3, 0x31,
    0x06, 0xAD, 0x9C, 0x15, 0x2B, 0x05, 0x91, 0x9D, 0x33, 0x56, 0xCE, 0x11, 0x72, 0x61, 0xF2, 0xCC,
    0x9A, 0x45, 0xCF, 0xCC, 0xCB, 0x8A, 0x72, 0xBE, 0x74, 0xFD, 0xAB, 0xC9, 0xDA, 0xB1, 0x6D, 0x30,
    0x23, 0x85, 0xA0, 0x62, 0x66, 0x7E, 0xF3, 0xB7, 0xC4, 0xFB, 0xFD, 0x36, 0xC6, 0xC1, 0x15, 0x5F,
    0xA4, 0xA9, 0x67, 0xB6, 0xD2, 0x99, 0xE1, 0x6E, 0x03, 0xF8, 0x73, 0x2E, 0x2E, 0x54, 0xDE, 0x63,
    0xFE, 0x45, 0x95, 0x67, 0xED, 0x82, 0x10, 0x80, 0x6D, 0x7D, 0x87, 0xD9, 0x79, 0x31, 0x20, 0xC4,
    0xC6, 0x09, 0xEE, 0x25, 0x5B, 0xD3, 0x91, 0x09, 0xD6, 0x94, 0x1A, 0x6B, 0x76, 0x9E, 0xEB, 0x84,
    0x30, 0x8E, 0x86, 0x28, 0x6E, 0x85, 0x87, 0x9C, 0x6B, 0x85, 0xB7, 0x45, 0x43, 0xDA, 0x41, 0x74,
    0x81, 0x08, 0xE3, 0x82, 0x86, 0x39, 0x14, 0x85, 0x74, 0x62, 0x1E, 0x27, 0x13, 0xA0, 0x72, 0x71,
    0xE1, 0x50, 0xFB, 0x67, 0xE2, 0xD2, 0xE1, 0xE9, 0x85, 0xE4, 0xD5, 0x74, 0xBE, 0x62, 0xD6, 0x82,
    0x2C, 0xFD, 0x80, 0xE4, 0x9D, 0x8A, 0x3B, 0xB8, 0xA6, 0x25, 0x64, 0x3B, 0x1E, 0x18, 0x2A, 0x38,
    0xBB, 0xEB, 0x5B, 0x17, 0xD3, 0x38, 0xD8, 0x00, 0xB5, 0x71, 0xE0, 0x1A, 0xE5, 0x09, 0x17, 0x86,
    0xC0, 0xDE, 0x9A, 0x89, 0x09, 0xBD, 0x1C, 0x19, 0x23, 0xE3, 0xF5, 0x78, 0x9A, 0xC4, 0x62, 0x1E,
    0x2B, 0x0A, 0xEF, 0x8B, 0xDE, 0x04, 0x44, 0x6E, 0x26, 0x81, 0x1F, 0xE1, 0x88, 0x34, 0xF5, 0xC1,
    0xD0, 0x26, 0xAB, 0xD6, 0x54, 0x72, 0xB3, 0x64, 0x0C, 0x73, 0x36, 0x2A, 0x63, 0x3D, 0x5C, 0x07,
    0xD4, 0xB5, 0x8C, 0x83, 0x16, 0x35, 0xCF, 0xCB, 0xA2, 0x80, 0x90, 0xE3, 0x2B, 0x08, 0x0F, 0x75,
    0xC0, 0xF5, 0xB8, 0x21, 0xDE, 0x72, 0x91, 0x8C, 0x53, 0x91, 0x8C, 0x93, 0x58, 0x22, 0xDC, 0x61,
    0x68, 0xBC, 0xCA, 0x52, 0x26, 0x85, 0x02, 0x0A, 0x88, 0x25, 0x23, 0x61, 0x9C, 0xC2, 0x36, 0xD9,
    0x5F, 0x59, 0xDF, 0x7F, 0x4F, 0xD9, 0x04, 0x9B, 0xD8, 0x80, 0x8A, 0x32, 0x4E, 0xDF, 0x59, 0xAE,
    0x6E, 0x73, 0xEE, 0x36, 0xCA, 0x44, 0xE1, 0xE5, 0x0A, 0x52, 0xFA, 0x82, 0xB8, 0x89, 0x4D, 0x70,
    0x75, 0x66, 0xE7, 0x0C, 0x81, 0x70, 0x39, 0x64, 0x4A, 0x46, 0x8E, 0x0D, 0x6C, 0x2C, 0xC6, 0x99,
    0x78, 0x3D, 0x34, 0x8C, 0x2C, 0x82, 0x70, 0x03, 0x21, 0x4F, 0x8D, 0x20, 0xF2, 0xB7, 0x94, 0x2F,
    0x19, 0xFA, 0xEB, 0x61, 0x0A, 0x9D, 0xEB, 0x5E, 0xE2, 0xD5, 0xF1, 0xB6, 0xBB, 0xE8, 0xB7, 0xE8,
    0x66, 0x0B, 0xA5, 0x82, 0xB7, 0xDB, 0x2C, 0x48, 0xD0, 0xF8, 0xBD, 0x2D, 0x3F, 0xA4, 0xE1, 0x1E,
    0x1E, 0x71, 0x07, 0xC9, 0x9A, 0x30, 0xD7, 0x07, 0x24, 0xCE, 0x57, 0x49, 0x3E, 0xED, 0x19, 0x54,
    0x9C, 0x85, 0x00, 0xB4, 0x3F, 0x2A, 0x8E, 0xEA, 0x47, 0xC5, 0xDE, 0xDE, 0xA0, 0xC8, 0xE2, 0x4D,
    0x1A, 0x33, 0xE4, 0x70, 0x92, 0xCF, 0x4D, 0x92, 0x7D, 0xCB, 0x41, 0xAF, 0x2C, 0x9F, 0xA8, 0xC4,
    0x35, 0x59, 0xFA, 0xD6, 0x2E, 0x54, 0x08, 0x2D, 0x7E, 0x11, 0xC7, 0x16, 0x76, 0x93, 0x15, 0xA0,
    0xBF, 0x8B, 0xA8, 0xC7, 0xF3, 0xB0, 0x93, 0x89, 0xB9, 0x22, 0xD9, 0xE6, 0x98, 0xA4, 0x76, 0x8D,
    0x6D, 0x08, 0xE4, 0x06, 0xA2, 0xBF, 0xA8, 0x53, 0x17, 0xB2, 0xD8, 0xB0, 0xA5, 0x8C, 0x60, 0x5C,
    0x7F, 0x50, 0x5B, 0x11, 0x0C, 0x2C, 0x5B, 0x02, 0x69, 0xA2, 0x18, 0xDD, 0xD9, 0xE0, 0x15, 0x99,
    0xEC, 0x02, 0xB7, 0xD9, 0xB0, 0x71, 0x84, 0x27, 0xEC, 0xBE, 0x1B, 0x5E, 0xAE, 0x7E, 0xBE, 0xDE,
    0xB8, 0xED, 0x57, 0xFD, 0x13, 0xB8, 0x44, 0x70, 0xE9, 0x85, 0x33, 0x6D, 0x1D, 0x45, 0xDB, 0x49,
    0xB7, 0x7B, 0x75, 0x75, 0xD5, 0xB9, 0xEA, 0x77, 0xFC, 0x60, 0xD5, 0x35, 0x0D, 0xC3, 0xA0, 0x83,
    0x35, 0x6E, 0x15, 0x33, 0xAD, 0x67, 0x6A, 0x88, 0xBB, 0x29, 0xBF, 0x5E, 0x3A, 0xAE, 0x3B, 0xD3,
    0x5E, 0x99, 0x7D, 0x6E, 0x82, 0xDA, 0xAB, 0xFE, 0x29, 0xC0, 0xDC, 0xE2, 0x68, 0x8D, 0xEC, 0x99,
    0xF6, 0xD1, 0x44, 0x03, 0x77, 0x80, 0xE0, 0x97, 0x3E, 0xD0, 0xBA, 0xFC, 0x1D, 0x05, 0x07, 0x57,
    0x8D, 0x96, 0x4C, 0x65, 0x40, 0x80, 0x01, 0x1A, 0xA8, 0xE3, 0x2B, 0xF9, 0xDD, 0xD6, 0x8F, 0x35,
    0xC9, 0x42, 0x22, 0x33, 0x43, 0xC4, 0x23, 0x7F, 0x5E, 0x0E, 0xC8, 0xDF, 0xD2, 0x81, 0x72, 0x35,
    0xF0, 0xB2, 0x87, 0x7B, 0xD8, 0x24, 0xD9, 0x2A, 0x32, 0x57, 0x10, 0x40, 0x6D, 0xE6, 0x6F, 0x50,
    0xE4, 0xAF, 0x56, 0xB4, 0x24, 0xB8, 0x72, 0x22, 0x6B, 0x9D, 0x89, 0x0D, 0xFC, 0x8D, 0x1E, 0xF8,
    0x57, 0x8F, 0x5A, 0xE7, 0xF5, 0xB2, 0x75, 0x5E, 0x8A, 0x05, 0xC1, 0x2C, 0xEF, 0x36, 0x5F, 0x7B,
    0xC5, 0x1C, 0x58, 0x86, 0x65, 0xD8, 0x46, 0x61, 0xDE, 0x6D, 0x2A, 0x25, 0xE2, 0x42, 0x05, 0x77,
    0x49, 0xE2, 0x54, 0x33, 0x18, 0xA4, 0x81, 0xD5, 0x64, 0x21, 0xA4, 0x24, 0x8E, 0xC6, 0xFC, 0x33,
    0x7B, 0xBF, 0xF5, 0x81, 0x6E, 0x27, 0xBA, 0x81, 0x14, 0xC0, 0xA1, 0x18, 0x02, 0x84, 0x62, 0x46,
    0x27, 0x04, 0x67, 0x86, 0x6C, 0x99, 0xAD, 0x14, 0x04, 0x39, 0x78, 0x01, 0xCE, 0xBE, 0x8B, 0xC8,
    0xD4, 0xF1, 0xA0, 0xA9, 0x01, 0x40, 0xFB, 0x2A, 0x86, 0xBD, 0x01, 0x05, 0xCA, 0x93, 0x5C, 0x5A,
    0x60, 0xFC, 0xEC, 0x2F, 0x1F, 0x87, 0xEA, 0xFA, 0x31, 0x4B, 0xFA, 0xC1, 0x54, 0x5E, 0xE4, 0xC6,
    0x25, 0xCB, 0x68, 0xD2, 0x07, 0xF4, 0x34, 0x32, 0xF7, 0xF3, 0x64, 0xC4, 0x21, 0x54, 0xCA, 0x69,
    0x3D, 0x75, 0x52, 0x2B, 0x6D, 0x7E, 0xE2, 0x6C, 0x5E, 0x93, 0x1F, 0xA6, 0xBC, 0x89, 0xB5, 0x26,
    0xD6, 0x05, 0xB1, 0x7F, 0x16, 0x8A, 0xD9, 0x53, 0x1C, 0xF7, 0x5B, 0x15, 0x81, 0x28, 0x32, 0x3C,
    0xBB, 0x02, 0x5B, 0x23, 0xFF, 0x6A, 0x9A, 0x90, 0x1F, 0x64, 0x7F, 0x16, 0x81, 0x2E, 0xEB, 0x68,
    0x7F, 0x87, 0x9E, 0x18, 0x1C, 0x8C, 0xC1, 0xCB, 0x38, 0x58, 0x40, 0x5F, 0xE8, 0xAC, 0x21, 0xAB,
    0x52, 0xEB, 0xD1, 0x6C, 0x74, 0xA7, 0x9A, 0x9D, 0x89, 0xE3, 0xEC, 0x71, 0xE3, 0xF7, 0x5C, 0x8F,
    0x0A, 0x60, 0x27, 0xBD, 0xA9, 0xA8, 0xF7, 0xF2, 0x71, 0x33, 0x7F, 0x9F, 0x99, 0x2B, 0x15, 0x6C,
    0x59, 0x45, 0xF6, 0x6B, 0xE5, 0x45, 0xC8, 0x71, 0x99, 0x04, 0xA1, 0x52, 0xE7, 0x7E, 0x96, 0xD2,
    0x7A, 0x95, 0xCB, 0x52, 0x8F, 0xD6, 0x90, 0xB3, 0xB2, 0x8C, 0x96, 0x71, 0x58, 0x62, 0x99, 0x7B,
    0xB2, 0x2E, 0x35, 0xD3, 0xA2, 0x66, 0xF7, 0xBB, 0x71, 0x36, 0xA3, 0x8D, 0x15, 0xF9, 0xAC, 0xDF,
    0xBA, 0x1F, 0xE3, 0x1B, 0xFF, 0xAB, 0xCE, 0x07, 0x29, 0x98, 0xDE, 0xEB, 0x76, 0x0A, 0x8D, 0x3E,
    0x88, 0xD1, 0x02, 0xD5, 0x0B, 0x6C, 0xAF, 0x72, 0x21, 0x84, 0x2E, 0x50, 0x70, 0xA2, 0xFA, 0xB4,
    0x78, 0x62, 0x3D, 0x36, 0x33, 0x6A, 0x61, 0xCE, 0xC9, 0x82, 0x05, 0x88, 0x68, 0x7C, 0xC8, 0x8C,
    0xE4, 0x72, 0x20, 0x89, 0x85, 0xFB, 0xDA, 0xED, 0xBD, 0xD5, 0xD4, 0xA8, 0xBC, 0x58, 0x8D, 0x39,
    0xCF, 0xF7, 0x6F, 0x12, 0xEB, 0xB2, 0x5B, 0x9F, 0x45, 0x8E, 0x75, 0x71, 0x83, 0x42, 0x7C, 0x49,
    0x80, 0xE4, 0xAC, 0x67, 0xD3, 0x87, 0x20, 0x98, 0xB2, 0xE4, 0xB0, 0x74, 0xAE, 0x89, 0x3D, 0x8D,
    0xF3, 0xA1, 0xC1, 0x83, 0xAA, 0x31, 0xE5, 0xAD, 0x8F, 0xB1, 0x5F, 0x18, 0xBD, 0x61, 0x1B, 0x7E,
    0xF7, 0x81, 0xCD, 0xA3, 0x61, 0xAB, 0x38, 0xD4, 0x0E, 0xFC, 0xAD, 0x0E, 0xC5, 0x09, 0x08, 0x19,
    0x2A, 0xE9, 0x5D, 0xD0, 0xA4, 0x65, 0x83, 0x5A, 0x1E, 0x34, 0x82, 0xD7, 0x6A, 0xD5, 0xB3, 0x5D,
    0x30, 0x95, 0xE3, 0x57, 0xDD, 0xF1, 0x6C, 0x1A, 0x59, 0x0C, 0x65, 0xCF, 0x94, 0x88, 0x01, 0x86,
    0x79, 0x10, 0x90, 0xF7, 0xAE, 0x3A, 0x65, 0xDB, 0x5D, 0x45, 0xBC, 0x5B, 0x44, 0x9E, 0x4E, 0x01,
    0x2A, 0x23, 0x5B, 0x42, 0x9B, 0x99, 0x33, 0xFC, 0xDC, 0xFA, 0x82, 0x91, 0x37, 0xB6, 0x7C, 0x73,
    0x9E, 0x57, 0xFE, 0x3E, 0x7F, 0x17, 0x66, 0xC3, 0x17, 0xEC, 0x14, 0x3E, 0x74, 0xAF, 0x25, 0x9E,
    0x98, 0xCD, 0xE2, 0x0A, 0xCF, 0xCB, 0x7E, 0xDF, 0xA6, 0x0D, 0x40, 0x2E, 0xCC, 0xD0, 0x24, 0x84,
    0xF6, 0x26, 0x38, 0x0A, 0x92, 0xC2, 0x29, 0x59, 0xD4, 0xA0, 0x4E, 0x48, 0x81, 0x4C, 0xAB, 0x74,
    0x2A, 0xFB, 0x9D, 0x8B, 0xC9, 0x57, 0x22, 0x99, 0xF1, 0xBC, 0xC5, 0x01, 0x78, 0xBD, 0x52, 0x74,
    0x72, 0x7B, 0x28, 0xAF, 0x90, 0xEC, 0x11, 0x7A, 0x0D, 0x31, 0x52, 0x42, 0x84, 0x18, 0xF7, 0x2F,
    0x01, 0xD1, 0x15, 0x3A, 0x79, 0x0D, 0x31, 0xD3, 0x3C, 0x53, 0x67, 0x45, 0xDC, 0x59, 0xA1, 0x5A,
    0xC6, 0x61, 0x94, 0xAB, 0x92, 0xE1, 0x49, 0x15, 0x3F, 0x1F, 0x53, 0xD9, 0x30, 0x57, 0xA7, 0x11,
    0x57, 0x59, 0x4F, 0xE8, 0xF0, 0xA6, 0x85, 0x92, 0x07, 0xFF, 0x8E, 0x0B, 0x0C, 0xB5, 0xDA, 0xA8,
    0xDA, 0xCD, 0x41, 0x21, 0x2B, 0xEF, 0x35, 0xF1, 0xF1, 0x38, 0x67, 0xE2, 0x43, 0x23, 0x17, 0x6F,
    0xD2, 0x0A, 0x38, 0x2F, 0xE8, 0x7E, 0x98, 0xF8, 0xBB, 0x99, 0x9F, 0x15, 0x6B, 0x4A, 0x27, 0x97,
    0x74, 0x85, 0xA1, 0x3C, 0xC1, 0x33, 0x61, 0x75, 0xC2, 0x35, 0xB4, 0x14, 0x02, 0x51, 0xAF, 0xA2,
    0x28, 0x8C, 0x56, 0x11, 0xCE, 0xCE, 0xB2, 0x48, 0x18, 0x16, 0x0A, 0xBD, 0xFE, 0xA0, 0xDD, 0x3B,
    0x7A, 0xDD, 0x3E, 0x1A, 0xB0, 0x5C, 0xA0, 0xB6, 0x6A, 0x69, 0xCC, 0x20, 0xD1, 0xBD, 0x69, 0x5A,
    0xC3, 0x21, 0x29, 0xE0, 0x21, 0x41, 0xE0, 0x17, 0xCB, 0x49, 0xB3, 0x7F, 0xD4, 0x1E, 0x8D, 0xE9,
    0xEF, 0x72, 0x2C, 0xD2, 0x98, 0x14, 0x0B, 0x59, 0x0E, 0xE0, 0x47, 0x32, 0xB2, 0xFF, 0xD9, 0x10,
    0xDB, 0xC1, 0xCD, 0x34, 0x3C, 0x0E, 0x69, 0x78, 0x6C, 0x65, 0x8D, 0xAA, 0x7C, 0x41, 0xBC, 0x47,
    0x36, 0x77, 0xD9, 0xA1, 0xEA, 0xB5, 0x21, 0xF1, 0xD7, 0x5D, 0x4E, 0x33, 0xC7, 0xDD, 0x78, 0x5F,
    0xE4, 0xB8, 0xCB, 0xB7, 0x6C, 0x8E, 0xE9, 0xDC, 0x78, 0xCB, 0xC4, 0x76, 0x2E, 0x91, 0xE5, 0xE2,
    0x30, 0x9C, 0x35, 0x68, 0x79, 0xD2, 0x48, 0x77, 0x4F, 0xE4, 0x57, 0x09, 0x6D, 0xD2, 0x7B, 0x36,
    0x66, 0xDD, 0x2B, 0x6E, 0xED, 0xC0, 0xB3, 0xEC, 0x20, 0x8C, 0xD6, 0x01, 0x59, 0xCE, 0x1A, 0xDD,
    0x86, 0x80, 0x97, 0xAC, 0x73, 0x37, 0xE6, 0x6F, 0xE1, 0xF2, 0xB8, 0x8B, 0x25, 0xBC, 0x5D, 0x40,
    0x3C, 0x4F, 0xA5, 0x77, 0xCC, 0x16, 0xF1, 0x1C, 0x7B, 0xD6, 0x10, 0x28, 0xE8, 0x72, 0x57, 0x43,
    0x1A, 0xC1, 0x46, 0xFD, 0xA0, 0xEB, 0xE8, 0xFF, 0xF0, 0x85, 0x8B, 0x6D, 0xCF, 0x41, 0x1E, 0xA8,
    0x15, 0x62, 0x2C, 0x5C, 0xE9, 0x7A, 0x8E, 0x98, 0x78, 0xA1, 0x0F, 0xD1, 0x85, 0xBE, 0xEC, 0x2B,
    0xBE, 0x85, 0xC4, 0x17, 0xF2, 0xE6, 0xC7, 0xB4, 0x59, 0x15, 0xE4, 0x26, 0x8B, 0x7A, 0x0D, 0xC4,
    0x44, 0xC9, 0x19, 0xC8, 0x26, 0x83, 0xC6, 0x1C, 0xE4, 0x0C, 0x73, 0xE6, 0xE8, 0x2D, 0x0E, 0x1D,
    0x0B, 0x6E, 0x62, 0x48, 0x45, 0x1C, 0x92, 0x60, 0x85, 0x26, 0x1B, 0xC5, 0x61, 0xF9, 0xA1, 0xCB,
    0x55, 0xC9, 0x20, 0x36, 0x90, 0xAD, 0xE2, 0x41, 0x28, 0x08, 0x66, 0x8D, 0xFF, 0xEC, 0xA0, 0x16,
    0x8B, 0x00, 0xE4, 0x5F, 0x3E, 0x9F, 0xFE, 0x82, 0xE2, 0x3B, 0xD4, 0x34, 0xF4, 0x51, 0xBF, 0x8D,
    0x5C, 0xFF, 0x0A, 0x2C, 0x6C, 0x86, 0xA0, 0x77, 0x07, 0x87, 0x6E, 0x1D, 0x77, 0xD9, 0xC4, 0x3D,
    0x80, 0x59, 0xBD, 0x8A, 0x32, 0x6B, 0x48, 0x4C, 0x19, 0x02, 0x4B, 0xBC, 0x71, 0x97, 0xDC, 0x42,
    0x6D, 0x38, 0x6B, 0x18, 0xF0, 0x2F, 0xBE, 0x9E, 0x35, 0x46, 0xFD, 0x06, 0xBA, 0xC4, 0xEE, 0x0E,
    0x06, 0xF4, 0x8C, 0x32, 0x1E, 0xB9, 0xBE, 0x1F, 0x8D, 0xFD, 0x65, 0x00, 0x04, 0x51, 0xD7, 0x69,
    0xCC, 0xDF, 0xD3, 0x4B, 0x44, 0xAF, 0x0F, 0xF3, 0x19, 0x2F, 0xB5, 0x50, 0xD6, 0x52, 0x08, 0x31,
    0x73, 0x12, 0xC8, 0x52, 0x00, 0x0C, 0x08, 0x5F, 0xA8, 0x11, 0x2C, 0x0F, 0x1B, 0xF3, 0xBF, 0xFD,
    0xF3, 0x97, 0x37, 0xA8, 0xD9, 0x37, 0x8D, 0x6B, 0x73, 0x60, 0x80, 0xB4, 0xF9, 0x80, 0x5A, 0x50,
    0x46, 0x8D, 0xF9, 0xC9, 0x87, 0xF7, 0xA8, 0x39, 0x30, 0x00, 0xC8, 0xD1, 0xE8, 0x7E, 0x40, 0xC6,
    0x8D, 0x39, 0xA3, 0x64, 0x34, 0x30, 0xAE, 0x07, 0xE3, 0x7B, 0x52, 0x72, 0xD4, 0x98, 0x9F, 0x31,
    0x28, 0x63, 0x20, 0x05, 0x8A, 0xA7, 0xFB, 0x41, 0xA1, 0x86, 0xF0, 0x2F, 0x0A, 0xA5, 0x67, 0x98,
    0x83, 0xEB, 0xD7, 0xA3, 0xF1, 0x3D, 0xC1, 0x98, 0x40, 0x0D, 0x87, 0x63, 0x8E, 0x8D, 0x6B, 0x0A,
    0xEC, 0x9E, 0x80, 0xC0, 0x46, 0xB9, 0xF2, 0x89, 0x3D, 0xFF, 0x07, 0x87, 0x08, 0xCC, 0x5D, 0xF7,
    0xCC, 0x4A, 0x1C, 0x82, 0xA3, 0xB3, 0xC9, 0x0F, 0x32, 0xEE, 0x74, 0x91, 0x6C, 0x9F, 0x91, 0xB3,
    0xF0, 0xF2, 0xDE, 0x75, 0xB6, 0x08, 0x4A, 0x1E, 0xE8, 0x4E, 0xB0, 0x1B, 0x87, 0x9C, 0x43, 0x7E,
    0x91, 0xC1, 0x02, 0x81, 0x4A, 0xF6, 0x69, 0xB6, 0x20, 0x02, 0x25, 0x27, 0xF7, 0xEA, 0xCB, 0x25,
    0x80, 0x17, 0x66, 0x1F, 0xDF, 0xC4, 0x4B, 0x26, 0xB9, 0x90, 0xC8, 0x5A, 0xF4, 0x24, 0xE8, 0xED,
    0xF5, 0xAF, 0xC7, 0x17, 0xC2, 0x47, 0x87, 0xA6, 0x6C, 0xB4, 0xF6, 0x03, 0xE7, 0x2B, 0x64, 0xCA,
    0x27, 0x10, 0xC4, 0x7A, 0xC3, 0x50, 0x08, 0x51, 0x24, 0xB7, 0x4F, 0x25, 0x0C, 0xC5, 0x63, 0x78,
    0xC4, 0x73, 0x95, 0x2A, 0xD5, 0x7D, 0x5A, 0x04, 0xF8, 0x6B, 0x69, 0x76, 0x7B, 0x9C, 0xC4, 0x86,
    0xC7, 0xC3, 0xE1, 0xF2, 0x75, 0x9A, 0xD8, 0x3E, 0xD0, 0x35, 0xF6, 0xEF, 0x92, 0xD8, 0xE6, 0x6F,
    0x59, 0xF3, 0xEC, 0x41, 0x35, 0x88, 0x9A, 0xBA, 0x09, 0x65, 0x3A, 0x32, 0x2B, 0xE4, 0x2E, 0x09,
    0x49, 0xBA, 0x02, 0x73, 0x28, 0x86, 0xCB, 0x36, 0xC1, 0x17, 0x68, 0x98, 0x41, 0x2C, 0x12, 0x0A,
    0x84, 0x4D, 0xC8, 0x4F, 0x58, 0xD6, 0xD3, 0xCD, 0x38, 0xED, 0x99, 0x49, 0xD6, 0x33, 0xA8, 0x60,
    0xC9, 0x16, 0xA2, 0xCC, 0x21, 0xB4, 0xB2, 0x5A, 0xA4, 0x85, 0x97, 0x3C, 0x72, 0x9D, 0x01, 0x6E,
    0xCC, 0x8D, 0x83, 0x16, 0xBF, 0xC7, 0xE9, 0x1E, 0x2D, 0xE3, 0xCE, 0x4F, 0xC0, 0xFB, 0x02, 0xDA,
    0x32, 0x7D, 0x27, 0xAD, 0x58, 0x31, 0x7E, 0xA1, 0x93, 0xF4, 0xFE, 0x89, 0x35, 0x22, 0x10, 0x3D,
    0x33, 0x7D, 0x9C, 0xE1, 0x68, 0xC7, 0x4F, 0xBA, 0x7C, 0x2F, 0x8D, 0x84, 0x09, 0x05, 0x42, 0x27,
    0xF2, 0x93, 0x27, 0xD6, 0x4A, 0x8A, 0xEA, 0xB9, 0xE9, 0x65, 0x8D, 0x83, 0x6D, 0x1C, 0xBE, 0xFA,
    0x54, 0x2D, 0xFD, 0x6F, 0xAD, 0x16, 0x41, 0x40, 0xA2, 0x95, 0xF4, 0x01, 0x57, 0x4A, 0x3F, 0x56,
    0x4A, 0xFF, 0xD1, 0x95, 0x22, 0x30, 0x3D, 0x33, 0x9D, 0xBC, 0x23, 0x9E, 0xEF, 0x84, 0x04, 0x3A,
    0x23, 0xAA, 0x90, 0xF1, 0x37, 0x56, 0x88, 0xCD, 0xB1, 0x0B, 0x75, 0x24, 0xB7, 0x99, 0xFE, 0x69,
    0xFC, 0xD8, 0xBA, 0x88, 0xD1, 0x3C, 0xA1, 0x26, 0xEA, 0x16, 0x32, 0x6F, 0x76, 0x20, 0xFC, 0x0B,
    0x1A, 0x4D, 0x7D, 0xF7, 0xE6, 0x89, 0x0B, 0x9A, 0xE5, 0xF0, 0x88, 0x18, 0x8B, 0xB4, 0xA0, 0x61,
    0xB8, 0x2D, 0x8E, 0x3B, 0x7C, 0xFC, 0xC2, 0xA6, 0x46, 0x41, 0xCB, 0x28, 0x39, 0xBD, 0xDE, 0xFA,
    0xE1, 0x2E, 0x00, 0x8B, 0x7C, 0x73, 0x7A, 0xD2, 0x7A, 0xF4, 0x92, 0x16, 0x13, 0x4B, 0x58, 0x1B,
    0xBB, 0xFC, 0x56, 0x75, 0x7D, 0x15, 0x5F, 0x7C, 0x73, 0x8A, 0x7E, 0x25, 0x97, 0xC0, 0xCE, 0x77,
    0xCA, 0x5A, 0x98, 0x9C, 0xBB, 0x14, 0x7F, 0x2A, 0x20, 0x71, 0x5F, 0x96, 0xB1, 0xE8, 0xA3, 0xC7,
    0xF0, 0x48, 0x81, 0x49, 0xB8, 0xA4, 0x6E, 0x3E, 0xC0, 0x27, 0x39, 0x3A, 0x7A, 0xDE, 0x0A, 0xE0,
    0xA0, 0x19, 0xB2, 0xD9, 0x81, 0xBF, 0x36, 0xFA, 0x99, 0xDE, 0xF0, 0x22, 0x92, 0x04, 0x00, 0x9F,
    0x8D, 0xF8, 0x46, 0xBD, 0x1A, 0x33, 0xED, 0x5F, 0xB0, 0x03, 0x15, 0xC9, 0x9B, 0x5F, 0x9E, 0xC2,
    0xAC, 0x57, 0xA9, 0x59, 0xAF, 0xAC, 0x67, 0xD9, 0xAE, 0x32, 0x11, 0xFC, 0xEF, 0xDA, 0x89, 0x08,
    0x7A, 0x8B, 0x5D, 0xBA, 0x6B, 0xFD, 0xF8, 0x52, 0xB8, 0x5A, 0x24, 0x52, 0xA0, 0x97, 0xCF, 0xA5,
    0x4F, 0xFD, 0x42, 0x5C, 0xB2, 0x0A, 0xF0, 0xE6, 0x89, 0x23, 0x7B, 0x7F, 0x31, 0x36, 0x97, 0xA3,
    0x34, 0xB2, 0x27, 0x68, 0x3D, 0x3F, 0x72, 0x96, 0x8E, 0xC5, 0x6A, 0xC2, 0xEF, 0x1B, 0xE2, 0x3F,
    0xFA, 0xAC, 0x2C, 0xFF, 0x31, 0xC0, 0x41, 0x30, 0x4D, 0x09, 0xDC, 0xAE, 0xFD, 0xC8, 0x7F, 0x74,
    0x73, 0xD8, 0x30, 0x64, 0xE7, 0x51, 0x8C, 0x45, 0x98, 0x46, 0xFE, 0xF1, 0xB3, 0x5A, 0xD3, 0x51,
    0xCB, 0xE7, 0x12, 0x68, 0x7A, 0x32, 0xF9, 0x30, 0xE0, 0x39, 0xE1, 0xF0, 0x67, 0xCF, 0x49, 0x32,
    0x67, 0xEF, 0x50, 0x40, 0x3F, 0xC1, 0x40, 0xB7, 0x7A, 0x10, 0x88, 0x88, 0x13, 0xFA, 0xE8, 0x32,
    0x09, 0xED, 0x73, 0xBA, 0x51, 0x7F, 0xCE, 0x71, 0x25, 0x7D, 0x42, 0xF6, 0xE9, 0x73, 0xA8, 0x16,
    0xF8, 0x3A, 0x7F, 0xAC, 0x2E, 0xCB, 0xF7, 0x5D, 0xDB, 0xBF, 0xF2, 0x1A, 0xF3, 0x93, 0xF8, 0x0A,
    0xC5, 0xE7, 0x12, 0xB9, 0x6B, 0x41, 0xC7, 0x15, 0x3E, 0x60, 0x9B, 0x23, 0x8F, 0x25, 0x6B, 0x2B,
    0xE9, 0x63, 0x56, 0x26, 0x0C, 0x45, 0x0B, 0x35, 0x32, 0x8C, 0xA4, 0x50, 0xE8, 0x7F, 0xAB, 0x8D,
    0x0F, 0x16, 0xEA, 0x6E, 0xCE, 0xC3, 0x08, 0x07, 0x51, 0x63, 0xFE, 0xC6, 0xA2, 0xA7, 0x25, 0xD1,
    0xDA, 0xDF, 0x05, 0x21, 0xD2, 0xD1, 0x32, 0xF0, 0x37, 0x74, 0x0F, 0xC8, 0xEC, 0x3F, 0x40, 0x18,
    0x19, 0x0C, 0xB1, 0x24, 0xB2, 0xCF, 0x32, 0xDD, 0x8B, 0x29, 0xB7, 0x92, 0xDF, 0x54, 0x06, 0xC4,
    0xB3, 0x0B, 0x12, 0x80, 0x14, 0xFC, 0x48, 0xFC, 0x53, 0xE8, 0x59, 0xEE, 0xD9, 0x93, 0x32, 0xDE,
    0xE1, 0xF2, 0x60, 0xB5, 0x46, 0x3A, 0xAB, 0x0E, 0x32, 0x4D, 0xFD, 0x35, 0xD4, 0x69, 0xB4, 0x8C,
    0x0D, 0x01, 0x9A, 0xED, 0xD1, 0x7A, 0xED, 0x3E, 0xD5, 0x5A, 0xDD, 0x24, 0xFD, 0x8E, 0x44, 0xE4,
    0xC2, 0x22, 0xC8, 0x0F, 0xFD, 0xC5, 0x37, 0x5E, 0x53, 0xFE, 0x4C, 0x82, 0x10, 0x42, 0x1A, 0xE0,
    0xE0, 0x9F, 0x59, 0x82, 0x22, 0xF1, 0x43, 0xEB, 0xBB, 0xE6, 0xE9, 0x02, 0x45, 0xC4, 0xC3, 0x0B,
    0x97, 0xD8, 0x8F, 0x1E, 0x6F, 0xB7, 0x0C, 0xD1, 0x79, 0x82, 0x48, 0xD8, 0x54, 0xE1, 0xF9, 0xF3,
    0x89, 0xB9, 0x31, 0x69, 0xD0, 0x32, 0x2F, 0x81, 0x08, 0xA8, 0x63, 0x69, 0xD4, 0x15, 0xD7, 0x28,
    0x5A, 0x07, 0x24, 0x5C, 0x43, 0x44, 0x44, 0xCD, 0x57, 0x0F, 0xF0, 0xB2, 0x22, 0x92, 0xAC, 0x60,
    0xE4, 0x17, 0xCC, 0xE7, 0x7A, 0xC2, 0xE9, 0x8E, 0x8E, 0x12, 0xA7, 0x1B, 0x19, 0x87, 0x9D, 0xEE,
    0xA3, 0xE3, 0x75, 0x90, 0x25, 0xD1, 0xEF, 0xF3, 0xBB, 0x00, 0xAA, 0x32, 0x86, 0xEA, 0x31, 0x3A,
    0xA5, 0xFA, 0xB2, 0x2D, 0xCD, 0x67, 0x6F, 0x3E, 0x3C, 0x4A, 0x4A, 0xCB, 0x23, 0xCA, 0x4B, 0x37,
    0x93, 0xD2, 0x12, 0xD9, 0x66, 0x72, 0xDA, 0xA8, 0x66, 0x3C, 0xAF, 0x1B, 0x90, 0xA0, 0xE2, 0xF1,
    0xF0, 0x3A, 0xC0, 0x97, 0x78, 0xCF, 0x11, 0x8E, 0xA7, 0x59, 0x13, 0x92, 0x8B, 0xAD, 0xEF, 0x78,
    0x88, 0x03, 0xCA, 0x2E, 0x4E, 0xC6, 0xB9, 0x2D, 0x16, 0xCF, 0xE7, 0x7F, 0x4F, 0x8A, 0x40, 0xF1,
    0x0C, 0xE1, 0x25, 0x34, 0xF4, 0x71, 0x41, 0xF8, 0x30, 0xAB, 0x50, 0x20, 0x4C, 0x2B, 0xC0, 0xC2,
    0x9B, 0x6C, 0xB9, 0xF3, 0x3D, 0xAA, 0x1D, 0xA0, 0x0A, 0x90, 0x9F, 0xEF, 0x42, 0xBC, 0x82, 0x28,
    0xF4, 0x11, 0x5F, 0x53, 0xCD, 0xB1, 0xBB, 0x87, 0x45, 0x9F, 0x0C, 0xDC, 0x54, 0x02, 0xD2, 0x33,
    0xCE, 0xBB, 0x22, 0xE6, 0x1C, 0x55, 0x88, 0x39, 0x9F, 0x5C, 0x9B, 0x84, 0x11, 0xFD, 0x7C, 0x11,
    0x09, 0x11, 0x0E, 0x08, 0x3B, 0x1B, 0xAB, 0xDB, 0xD0, 0xED, 0x44, 0x2C, 0xC5, 0x7C, 0xBB, 0x78,
    0x03, 0x4C, 0x2D, 0xB7, 0xA1, 0x6C, 0x55, 0xEF, 0x3F, 0x9F, 0x3D, 0x48, 0x6E, 0x14, 0x5C, 0x2A,
    0x31, 0x76, 0xC7, 0x63, 0x48, 0x62, 0x27, 0xF7, 0x3E, 0x0D, 0x54, 0x37, 0x80, 0x7C, 0xFC, 0xDB,
    0x97, 0x2F, 0x4F, 0x1C, 0x38, 0xF8, 0x61, 0xC2, 0x34, 0x70, 0x30, 0x94, 0xCD, 0x3F, 0xFB, 0x1B,
    0x82, 0xDE, 0x84, 0xA1, 0x03, 0x05, 0xB1, 0x17, 0x7D, 0xDF, 0x4A, 0x86, 0x51, 0xF4, 0x54, 0xD5,
    0xCB, 0xE6, 0x3F, 0x51, 0x74, 0x1E, 0x03, 0x4F, 0xBA, 0x22, 0xF9, 0xD9, 0x33, 0xEA, 0x14, 0x29,
    0x59, 0x21, 0x09, 0x2E, 0x29, 0x01, 0x4C, 0x28, 0xFC, 0xA6, 0x9E, 0xB1, 0xB3, 0x4F, 0x49, 0xA6,
    0xAC, 0xC7, 0xF0, 0x64, 0xCE, 0xC5, 0xA3, 0xAD, 0x8B, 0x2D, 0x42, 0xEB, 0x20, 0x02, 0xC8, 0x7B,
    0x47, 0x66, 0xA7, 0x37, 0x1A, 0x77, 0x7A, 0x9D, 0x9E, 0xF1, 0xAD, 0x62, 0x23, 0xA3, 0x86, 0x7D,
    0x8D, 0x06, 0x67, 0x97, 0x5E, 0x3E, 0xA0, 0x05, 0x4E, 0xA0, 0xC9, 0xCC, 0xF2, 0x07, 0x19, 0xFF,
    0x1E, 0x0D, 0x87, 0xFD, 0x61, 0xEA, 0xE2, 0xE3, 0x71, 0xFF, 0x49, 0x9C, 0xFC, 0xB8, 0x4B, 0x4F,
    0x84, 0xC6, 0xE7, 0x57, 0xA5, 0xC3, 0xA2, 0xBC, 0x72, 0xC8, 0x7D, 0x6A, 0x43, 0xC4, 0x80, 0x8C,
    0xB7, 0xC5, 0x1F, 0x5B, 0x28, 0x39, 0xEC, 0x9A, 0xFD, 0x54, 0x43, 0xFE, 0xC4, 0xEB, 0x62, 0x17,
    0x45, 0x90, 0x6B, 0xB9, 0x98, 0xF8, 0x4D, 0x7A, 0xAC, 0x35, 0x3E, 0x94, 0xDE, 0x40, 0xBE, 0x67,
    0xB9, 0x40, 0x08, 0xFD, 0xF6, 0x12, 0x0F, 0xAA, 0xA9, 0x8E, 0xEB, 0xF3, 0x25, 0xC8, 0x0E, 0x3B,
    0x09, 0xAB, 0x75, 0x35, 0x71, 0xF0, 0x95, 0x43, 0xA8, 0x89, 0x83, 0x52, 0x28, 0xE1, 0x08, 0x77,
    0x8B, 0x8D, 0x13, 0xD1, 0x53, 0xB1, 0xCD, 0x56, 0x63, 0x7E, 0x46, 0x59, 0x4F, 0x4F, 0xE3, 0xE6,
    0x11, 0x48, 0x42, 0x2E, 0x08, 0xEF, 0x0B, 0x3B, 0xFD, 0x2E, 0x2F, 0x99, 0x66, 0xE5, 0x47, 0xAD,
    0x81, 0x1D, 0x99, 0x6E, 0xA4, 0x81, 0x82, 0xDE, 0xCD, 0x33, 0x90, 0x42, 0x2B, 0x70, 0xB6, 0xD2,
    0x79, 0xB8, 0xE5, 0xCE, 0xE3, 0x8D, 0x14, 0x3D, 0x17, 0xCE, 0x50, 0x34, 0xA9, 0x2F, 0xB5, 0x19,
    0x7F, 0x2D, 0x94, 0x3D, 0x06, 0x7D, 0x09, 0x3A, 0x8B, 0xE8, 0xCE, 0x85, 0x6F, 0xED, 0xE8, 0xC7,
    0xD9, 0x3B, 0x2B, 0x12, 0x9D, 0xF2, 0x4F, 0xB6, 0xBF, 0xBD, 0xF9, 0x60, 0x37, 0x35, 0x86, 0x51,
    0xCB, 0x1D, 0x9A, 0x8F, 0x3A, 0x14, 0xE2, 0x09, 0xFF, 0x64, 0x23, 0xCC, 0xA6, 0x77, 0xF9, 0x11,
    0x8C, 0xE2, 0xBF, 0xD2, 0x03, 0xA1, 0x33, 0xC4, 0xA1, 0x20, 0x0D, 0xFD, 0xCC, 0x88, 0x80, 0x7F,
    0x34, 0x46, 0x9D, 0x96, 0x9D, 0x04, 0x52, 0xFC, 0xE2, 0x6C, 0x88, 0xBF, 0x8B, 0x9A, 0x82, 0x89,
    0x26, 0x10, 0xAC, 0x04, 0xA6, 0x4D, 0xD1, 0x5D, 0x1B, 0x41, 0x29, 0x64, 0xB4, 0x94, 0x9F, 0x28,
    0x4A, 0xA4, 0xB0, 0xDB, 0xDA, 0x38, 0x22, 0x67, 0x2C, 0x1E, 0xFE, 0x93, 0xBA, 0x4A, 0xD3, 0xB1,
    0x55, 0x52, 0x88, 0x3F, 0x50, 0x58, 0x2E, 0x0A, 0x98, 0x36, 0x2D, 0xCC, 0x8A, 0x3F, 0x65, 0xB3,
    0x77, 0x1A, 0x65, 0x97, 0x6F, 0x37, 0xE5, 0xE5, 0xE8, 0x2C, 0xA1, 0x88, 0xE4, 0x78, 0x7F, 0xFC,
    0x51, 0xC0, 0x6A, 0x89, 0x8B, 0x9C, 0x90, 0xF9, 0xC0, 0x0E, 0x03, 0xA4, 0x64, 0x39, 0xA1, 0x00,
    0xDB, 0xF6, 0x29, 0xFD, 0xE4, 0xC0, 0xAF, 0x90, 0x15, 0x09, 0xF8, 0x54, 0x53, 0x7B, 0xF7, 0xE9,
    0x63, 0x0C, 0xE8, 0x57, 0x1F, 0xDB, 0xC4, 0xD6, 0xDA, 0x48, 0x96, 0x70, 0x86, 0xA8, 0xDF, 0xB4,
    0xF4, 0xF8, 0x13, 0x8C, 0xD3, 0xC4, 0xD1, 0x1B, 0x7A, 0x9D, 0x1E, 0xF8, 0x60, 0x77, 0xE2, 0xA4,
    0x01, 0xBD, 0x89, 0xB7, 0xBA, 0xE9, 0xA5, 0xD8, 0x63, 0xD3, 0x7E, 0xEF, 0x40, 0xE8, 0x38, 0xC5,
    0xD6, 0x3A, 0xD5, 0x67, 0x51, 0xF8, 0xF7, 0x57, 0x40, 0x56, 0x84, 0x2D, 0x21, 0xA1, 0x22, 0xFB,
    0x2C, 0xD4, 0xE6, 0x78, 0x56, 0x1B, 0x06, 0x58, 0x55, 0x0E, 0x89, 0x7C, 0x4F, 0xAF, 0x93, 0x9B,
    0x38, 0xD4, 0x14, 0xB1, 0xB9, 0x20, 0xE2, 0x7D, 0x02, 0x5E, 0x92, 0x08, 0x24, 0xA2, 0x75, 0xA1,
    0x64, 0x89, 0x76, 0xA1, 0xD6, 0x2A, 0xF0, 0xD4, 0x89, 0xD6, 0xC4, 0x4B, 0x45, 0x16, 0x50, 0x6A,
    0x03, 0x02, 0x92, 0xF7, 0x50, 0xD0, 0xF9, 0x23, 0xA4, 0x20, 0x29, 0x9D, 0x87, 0xE6, 0xD1, 0x0F,
    0xEA, 0xAB, 0x84, 0x2D, 0xC4, 0x46, 0xDF, 0x77, 0xFE, 0xD8, 0x92, 0xD5, 0xB9, 0x38, 0xB4, 0xFE,
    0xC3, 0x6C, 0x86, 0xA0, 0xD8, 0x22, 0x4B, 0xC7, 0x23, 0xA0, 0xA7, 0xD2, 0xA0, 0x10, 0x8F, 0xD7,
    0x5A, 0xDC, 0x1A, 0xD9, 0xCE, 0x67, 0x0E, 0xD6, 0x74, 0x3F, 0x5A, 0x76, 0xC4, 0xFB, 0x9C, 0x9E,
    0xF1, 0xAE, 0x8C, 0x34, 0x39, 0x15, 0x9E, 0x47, 0x9B, 0xC2, 0x3A, 0x80, 0x94, 0x1D, 0xB0, 0xAD,
    0x8C, 0x8F, 0x8D, 0x06, 0x5C, 0xF1, 0xD6, 0x1E, 0x60, 0x93, 0xA1, 0xCC, 0x00, 0x4A, 0xAF, 0x75,
    0x00, 0x61, 0x7C, 0x8C, 0xB5, 0x32, 0xCA, 0x78, 0xBC, 0x02, 0xA9, 0x80, 0x24, 0xD0, 0xEE, 0xC7,
    0x9B, 0x3A, 0x70, 0x1E, 0xF5, 0x6D, 0x39, 0x72, 0xC9, 0xEB, 0x73, 0x02, 0x4E, 0xDF, 0x4C, 0x15,
    0x5E, 0x93, 0x99, 0x38, 0x45, 0x77, 0xFB, 0x49, 0x13, 0xD1, 0xA4, 0x06, 0x61, 0x49, 0x00, 0xCA,
    0x91, 0x25, 0x9E, 0x2B, 0x89, 0x4A, 0x27, 0x1D, 0x24, 0x29, 0x0D, 0x6A, 0x35, 0x88, 0x92, 0x22,
    0x61, 0x8E, 0xAC, 0xF4, 0x8D, 0x92, 0x30, 0x79, 0xE2, 0x61, 0xD2, 0x92, 0x73, 0x6C, 0x35, 0x28,
    0x4B, 0xA2, 0x72, 0x9E, 0x30, 0xF1, 0x42, 0x4D, 0x57, 0x3A, 0xED, 0x20, 0x59, 0x71, 0xAC, 0xAF,
    0x41, 0x94, 0xC8, 0x0E, 0x39, 0x92, 0xE2, 0xC7, 0x4A, 0x82, 0x92, 0x29, 0x53, 0x39, 0xC9, 0x29,
    0xE9, 0xC1, 0xC4, 0xAA, 0xEC, 0x63, 0x30, 0x56, 0xE1, 0x5F, 0x14, 0x42, 0x25, 0x97, 0x16, 0xB9,
    0xAD, 0x06, 0xEF, 0x49, 0x3A, 0xCC, 0x31, 0x2F, 0x9E, 0x2B, 0xB9, 0x4F, 0x27, 0x1D, 0xD4, 0x06,
    0x5E, 0xD5, 0xE0, 0x7E, 0xA5, 0xE4, 0x7E, 0x55, 0x95, 0xFB, 0xAB, 0x45, 0x75, 0x54, 0x57, 0x0B,
    0x15, 0x2A, 0x80, 0x50, 0x2D, 0x88, 0xE5, 0x36, 0xCF, 0xCF, 0xD9, 0x5A, 0x6C, 0x65, 0xEC, 0xB9,
    0xD9, 0x19, 0x4A, 0xCA, 0xC1, 0x4F, 0xEB, 0x91, 0xC4, 0xF6, 0xAE, 0xEB, 0x92, 0xC4, 0x26, 0x1D,
    0xA6, 0x87, 0x0D, 0x3B, 0x40, 0x4F, 0x76, 0xB3, 0xB8, 0x32, 0x21, 0xD9, 0x69, 0x45, 0x52, 0xB2,
    0xEF, 0x6B, 0xCA, 0x44, 0x2C, 0x68, 0xD7, 0x15, 0x8B, 0x98, 0x97, 0xF7, 0x92, 0x32, 0xF8, 0xD5,
    0xC8, 0x92, 0xB7, 0x4B, 0xCF, 0xE9, 0xD6, 0x64, 0x65, 0xB2, 0xE4, 0x99, 0x25, 0x34, 0x15, 0x80,
    0xD7, 0xA2, 0x89, 0x78, 0xF6, 0xBD, 0x28, 0x82, 0x79, 0xFB, 0xE9, 0x11, 0x80, 0x0F, 0x39, 0x58,
    0x7E, 0xE3, 0x4B, 0x2C, 0x25, 0x55, 0x26, 0x28, 0x0F, 0xA0, 0x68, 0x49, 0x65, 0x28, 0xA6, 0x95,
    0x28, 0x4B, 0xF7, 0x8A, 0xCE, 0xD3, 0xBD, 0xAE, 0x9A, 0xC4, 0xA5, 0x30, 0x24, 0xA1, 0x7D, 0xC4,
    0xD1, 0xBA, 0xC3, 0xD6, 0x15, 0x0F, 0xE3, 0xFB, 0x89, 0x7E, 0xF9, 0x67, 0x6B, 0x5A, 0x53, 0x94,
    0xB5, 0xBD, 0x20, 0xB7, 0x1D, 0x94, 0xD7, 0x70, 0x29, 0x82, 0x43, 0x4A, 0xCE, 0xFA, 0x72, 0xB2,
    0xA5, 0x50, 0x27, 0x56, 0xE4, 0xA6, 0x16, 0xCA, 0x0A, 0x35, 0x86, 0xC3, 0xA1, 0x2B, 0x59, 0xE3,
    0x3F, 0x07, 0xEE, 0xE8, 0x37, 0x99, 0xD4, 0x21, 0x2A, 0x99, 0xAC, 0x20, 0xA7, 0x00, 0xF8, 0x30,
    0x2D, 0x31, 0xF1, 0xCB, 0x6D, 0x58, 0x87, 0x08, 0x18, 0xAE, 0x40, 0x9F, 0xC2, 0x3A, 0x98, 0xE2,
    0xA4, 0x05, 0xDC, 0xEA, 0xF1, 0x52, 0x9A, 0xA4, 0x48, 0x23, 0xD2, 0xDB, 0x69, 0x05, 0xEC, 0x7C,
    0x11, 0xB5, 0x1E, 0x72, 0x3E, 0xA7, 0x10, 0x84, 0xD2, 0x57, 0x55, 0x10, 0xD3, 0x05, 0xCD, 0x7A,
    0x68, 0xE9, 0x0C, 0x25, 0x52, 0xFA, 0xA2, 0x88, 0x52, 0xD5, 0x20, 0x5B, 0x38, 0x92, 0x17, 0x23,
    0x48, 0xC0, 0x7A, 0x6B, 0xF0, 0xFB, 0xD0, 0x77, 0x09, 0xFF, 0x62, 0x82, 0xA6, 0xF6, 0x1E, 0x3B,
    0x54, 0x1F, 0x50, 0x6C, 0xD0, 0x4E, 0x1E, 0xF1, 0x36, 0x7D, 0x02, 0x1D, 0x3D, 0x1D, 0x3E, 0x2D,
    0x5F, 0x10, 0x48, 0x17, 0xDE, 0xA4, 0x05, 0x42, 0xC5, 0x4A, 0x13, 0x25, 0x1C, 0xE8, 0x2F, 0x36,
    0xE6, 0x72, 0xFF, 0x3C, 0x41, 0x5B, 0xFA, 0xF5, 0xCE, 0x1F, 0xBC, 0xA8, 0x59, 0xB5, 0x0D, 0x6F,
    0xB5, 0x0B, 0x10, 0xD3, 0xD6, 0xB8, 0x0A, 0xBC, 0x42, 0x87, 0xAD, 0x80, 0xC8, 0xBA, 0xDF, 0x49,
    0xE5, 0xAE, 0xB9, 0x08, 0x20, 0xEE, 0x64, 0x27, 0x35, 0xBA, 0xE0, 0x22, 0x90, 0xB4, 0xE5, 0xAC,
    0xC2, 0x57, 0xB1, 0xB3, 0x55, 0x30, 0x26, 0x1A, 0xC6, 0x2A, 0x00, 0xF3, 0x1D, 0xA9, 0x02, 0x5C,
    0xDA, 0xE6, 0x55, 0x01, 0x58, 0xEC, 0x26, 0x55, 0x20, 0x45, 0x87, 0x56, 0x09, 0x62, 0xBE, 0x0B,
    0x54, 0x00, 0x8C, 0x3B, 0xAC, 0x2A, 0xE0, 0x72, 0xFD, 0x9B, 0x02, 0x18, 0x74, 0x50, 0x93, 0x8A,
    0x5D, 0x97, 0x6A, 0x32, 0xEF, 0x76, 0xAA, 0x90, 0x92, 0x6F, 0xA7, 0x54, 0xB4, 0xAC, 0xF6, 0xD2,
    0xB2, 0xDA, 0x4F, 0xCB, 0xD5, 0x62, 0x52, 0xB1, 0xAB, 0x29, 0x4E, 0x56, 0x76, 0x15, 0x93, 0x7B,
    0xB4, 0x29, 0x87, 0x41, 0xB3, 0x06, 0x61, 0x52, 0xB7, 0xDD, 0x50, 0x98, 0x55, 0x26, 0x7F, 0x4F,
    0xEA, 0xB7, 0x0D, 0x87, 0x49, 0x15, 0xC5, 0x4A, 0x15, 0xF5, 0x96, 0xB4, 0x03, 0xAD, 0x52, 0x2C,
    0x85, 0x2A, 0xBC, 0x0A, 0x16, 0x55, 0x75, 0x7F, 0x10, 0x85, 0x28, 0xAC, 0x6B, 0x20, 0x90, 0x8A,
    0x75, 0x05, 0xF8, 0xB2, 0xF2, 0x78, 0x72, 0x9F, 0x9A, 0xBB, 0x14, 0xBC, 0xAA, 0xAC, 0xAD, 0xC2,
    0x42, 0x69, 0x05, 0xDD, 0x42, 0x5D, 0x5A, 0x14, 0x77, 0x8C, 0x0A, 0x1C, 0xD5, 0x51, 0x7D, 0x49,
    0x0D, 0xDC, 0x3A, 0x64, 0xB3, 0x49, 0xCD, 0x59, 0x29, 0x30, 0x96, 0x16, 0xB4, 0x6A, 0x3C, 0x85,
    0x62, 0xB2, 0x22, 0x92, 0x42, 0x81, 0xAA, 0x06, 0x9F, 0x16, 0x8B, 0x15, 0xE1, 0x4A, 0x35, 0xA7,
    0xCA, 0x60, 0xA5, 0xF2, 0x6F, 0x52, 0xB7, 0x86, 0x2C, 0x01, 0xC7, 0x6B, 0xBA, 0x49, 0xAD, 0xA2,
    0xB0, 0x04, 0x14, 0xAD, 0xD4, 0x2A, 0x05, 0x81, 0x7C, 0xBD, 0x97, 0xAD, 0xE5, 0xEE, 0x72, 0x85,
    0x75, 0xB2, 0xA3, 0x12, 0x6F, 0xC3, 0x42, 0xAD, 0x56, 0xAC, 0xAE, 0x36, 0x24, 0x5A, 0xFB, 0x20,
    0x14, 0xED, 0xF3, 0xA7, 0xB3, 0x2F, 0x9A, 0xA2, 0x30, 0x61, 0xDF, 0xB8, 0x04, 0x6A, 0xB8, 0x45,
    0x5A, 0xBC, 0x59, 0xA6, 0x7F, 0xB9, 0xD9, 0x12, 0x0D, 0xA6, 0xD0, 0xFF, 0x75, 0x22, 0xDE, 0xA2,
    0xED, 0xD2, 0x0D, 0x18, 0x0D, 0xDD, 0x29, 0x8A, 0x12, 0xDF, 0x86, 0xB2, 0xED, 0x2F, 0x67, 0x9F,
    0xFE, 0xDA, 0x09, 0xA3, 0x00, 0xE8, 0x80, 0x00, 0xC0, 0x37, 0x61, 0x5E, 0xEC, 0xA9, 0x4B, 0xEF,
    0xB3, 0xD9, 0x93, 0x9F, 0x43, 0xC2, 0x9D, 0x1B, 0xA9, 0xB6, 0x7A, 0xD2, 0x2D, 0x60, 0x3E, 0xA6,
    0x03, 0xF5, 0x1D, 0x3B, 0xB3, 0xF5, 0xDF, 0xFF, 0x22, 0xED, 0x2C, 0x96, 0x16, 0xDB, 0xBD, 0xB7,
    0x7F, 0x00, 0xA1, 0xC5, 0x83, 0xE2, 0x2F, 0x02, 0x43, 0x7F, 0x42, 0x5A, 0x7C, 0xA9, 0x21, 0x10,
    0x02, 0xE1, 0x55, 0xD9, 0x74, 0x2F, 0x37, 0xCA, 0x0A, 0x7B, 0x0F, 0x5D, 0xDA, 0x29, 0xAF, 0x06,
    0xE9, 0xDE, 0x30, 0x0C, 0x6E, 0x97, 0xA2, 0x99, 0x16, 0xBF, 0x66, 0x2B, 0xDE, 0xF8, 0x3E, 0xEE,
    0xF2, 0x2F, 0xD8, 0x3A, 0xEE, 0xF2, 0xFF, 0x3A, 0xE5, 0xFF, 0x01, 0x62, 0xF8, 0xFD, 0x23, 0x4C,
    0x65, 0x00, 0x00
};
const size_t SETTINGS_HTML_GZ_LEN = sizeof(SETTINGS_HTML_GZ);

// Handler: Main page - HTML GUI
static esp_err_t index_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "text/html");
    httpd_resp_set_hdr(req, "Content-Encoding", "gzip");
    return httpd_resp_send(req, (const char*)INDEX_HTML_GZ, INDEX_HTML_GZ_LEN);
}

// Handler: Single JPEG frame (reads from ring buffer -- no direct esp_camera_fb_get!)
static esp_err_t frame_handler(httpd_req_t *req) {
    int idx = getLatestFrameIndex();
    if (idx < 0) {
        Serial.println("Camera frame not available yet");
        httpd_resp_set_type(req, "application/json");
        httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "{\"error\":\"frame_not_available\"}");
        return ESP_FAIL;
    }

    if (!acquireFrameReader(idx)) {
        // Writer active, brief pause then retry
        vTaskDelay(pdMS_TO_TICKS(5));
        idx = getLatestFrameIndex();
        if (idx < 0 || !acquireFrameReader(idx)) {
            httpd_resp_set_type(req, "application/json");
            httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "{\"error\":\"frame_busy\"}");
            return ESP_FAIL;
        }
    }

    // Validate frame data
    if (frameBuffers[idx].data == NULL || frameBuffers[idx].len == 0) {
        releaseFrameReader(idx);
        Serial.println("Ring buffer frame empty");
        httpd_resp_set_type(req, "application/json");
        httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "{\"error\":\"frame_empty\"}");
        return ESP_FAIL;
    }

    httpd_resp_set_type(req, "image/jpeg");
    httpd_resp_set_hdr(req, "Content-Disposition", "inline; filename=capture.jpg");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");

    esp_err_t res = httpd_resp_send(req, (const char *)frameBuffers[idx].data,
                                     frameBuffers[idx].len);

    releaseFrameReader(idx);
    return res;
}

// Global variables for client tracking (atomic for thread safety across httpd workers)
static int active_stream_clients = 0;
static int active_detection_clients = 0;
const int MAX_STREAM_CLIENTS = 2;  // Max clients pro GUI stream
const int MAX_DETECTION_CLIENTS = 2;  // Increased to allow two detection clients (e.g., a8.py and test script)

// Helper: set send timeout on HTTP stream socket
static void setStreamSocketTimeout(httpd_req_t *req, int timeout_ms = 500) {
    int sockfd = httpd_req_to_sockfd(req);
    struct timeval send_timeout;
    send_timeout.tv_sec = timeout_ms / 1000;
    send_timeout.tv_usec = (timeout_ms % 1000) * 1000;
    if (setsockopt(sockfd, SOL_SOCKET, SO_SNDTIMEO, &send_timeout, sizeof(send_timeout)) < 0) {
        Serial.println("Failed to set socket send timeout");
    }
}

// Helper function to set CORS headers
static void set_cors_headers(httpd_req_t *req) {
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Methods", "GET, POST, OPTIONS");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Headers", "Content-Type, Authorization");
    httpd_resp_set_hdr(req, "Access-Control-Max-Age", "86400"); // Cache preflight for 24 hours
}

// Handler: HEAD request for streams (checks availability)
static esp_err_t stream_head_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "multipart/x-mixed-replace;boundary=" PART_BOUNDARY);
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    httpd_resp_set_status(req, "200 OK");
    httpd_resp_send(req, NULL, 0);
    return ESP_OK;
}

// Generic Video Stream Handler to reduce duplication
static esp_err_t generic_video_stream_handler(httpd_req_t *req, int *active_clients, int max_clients, const char* stream_name, bool limit_fps) {
    esp_err_t res = ESP_OK;
    char part_buf[64];

    // Client limit check (atomic read)
    int current_count = __atomic_load_n(active_clients, __ATOMIC_SEQ_CST);
    if (current_count >= max_clients) {
        Serial.printf("⚠️  %s: Max clients reached, rejecting new connection\n", stream_name);
        char log_msg[128];
        snprintf(log_msg, sizeof(log_msg), "%s: Max clients reached, connection rejected", stream_name);
        send_udp_log("WARN", log_msg);
        httpd_resp_set_status(req, "429 Too Many Requests");
        httpd_resp_send(req, "Too many clients connected", HTTPD_RESP_USE_STRLEN);
        return ESP_FAIL;
    }

    __atomic_fetch_add(active_clients, 1, __ATOMIC_SEQ_CST);
    current_count = __atomic_load_n(active_clients, __ATOMIC_SEQ_CST);
    Serial.printf("✅ %s connected (clients: %d/%d)\n", stream_name, current_count, max_clients);

    char connect_msg[128];
    snprintf(connect_msg, sizeof(connect_msg), "%s connected (clients: %d/%d)",
             stream_name, *active_clients, max_clients);
    send_udp_log("INFO", connect_msg);

    res = httpd_resp_set_type(req, _STREAM_CONTENT_TYPE);
    if (limit_fps) {
        set_cors_headers(req);
        httpd_resp_set_hdr(req, "X-Framerate", "30");
    } else {
        httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    }
    
    httpd_resp_set_hdr(req, "Content-Disposition", "inline; filename=stream.mjpeg");

    if(res != ESP_OK) {
        __atomic_fetch_sub(active_clients, 1, __ATOMIC_SEQ_CST);
        return res;
    }

    // Set socket send timeout
    setStreamSocketTimeout(req, 500);

    // Zero-Copy Ring Buffer Implementation
    // No local buffer allocation needed!

    unsigned long frame_count = 0;
    unsigned long my_last_timestamp = 0;

    while(true) {
        // Wait for new frame
        bool new_frame = false;
        unsigned long wait_start = millis();
        int frame_idx = -1;

        while (!new_frame) {
            // Check timeout (if no frame for 2s, abort)
            if (millis() - wait_start > 2000) {
                break;
            }
            
            // Check if new frame available in Ring Buffer (CAS-safe reader)
            int idx = getLatestFrameIndex();
            if (idx >= 0 && frameBuffers[idx].timestamp > my_last_timestamp) {
                if (acquireFrameReader(idx)) {
                    frame_idx = idx;
                    my_last_timestamp = frameBuffers[idx].timestamp;
                    new_frame = true;
                }
            }
            
            if (!new_frame) {
                vTaskDelay(5); // Wait a bit
            }
        }

        if (!new_frame) {
            Serial.println("⚠️ MJPEG: No frame from capture task");
            res = ESP_FAIL;
            break;
        }

        // Send boundary
        res = httpd_resp_send_chunk(req, _STREAM_BOUNDARY, strlen(_STREAM_BOUNDARY));
        if(res == ESP_OK) {
            // Send header with length
            size_t hlen = snprintf((char *)part_buf, 64, _STREAM_PART, frameBuffers[frame_idx].len);
            res = httpd_resp_send_chunk(req, (const char *)part_buf, hlen);
        }
        
        if(res == ESP_OK) {
            // Send frame data directly from Ring Buffer (Zero-Copy!)
            res = httpd_resp_send_chunk(req, (const char *)frameBuffers[frame_idx].data, frameBuffers[frame_idx].len);
        }

        // Release frame reader reference
        releaseFrameReader(frame_idx);

        if(res != ESP_OK) {
            Serial.println("Stream send failed (timeout or disconnect)");
            // FIXED: Force close socket on error to prevent socket leak
            // Half-open sockets can accumulate after timeouts, exhausting available sockets
            int sockfd = httpd_req_to_sockfd(req);
            if (sockfd >= 0) {
                httpd_sess_trigger_close(stream_httpd, sockfd);
            }
            break;
        }
        
        if (limit_fps) {
            // Precise timing handled by capture task, but we can yield here
            // vTaskDelay(pdMS_TO_TICKS(1));
            // Actually, for detection stream we might want to limit rate if client is slow
             vTaskDelay(pdMS_TO_TICKS(33));
        }

        // Reset WDT periodically (every 30 frames = ~1 second at 30 FPS)
        if (frame_count % 30 == 0) {
            esp_task_wdt_reset();
        }

        frame_count++;
    }
    
    __atomic_fetch_sub(active_clients, 1, __ATOMIC_SEQ_CST);
    int remaining = __atomic_load_n(active_clients, __ATOMIC_SEQ_CST);
    Serial.printf("🔌 %s disconnected (clients: %d/%d, frames: %lu)\n", stream_name, remaining, max_clients, frame_count);

    char disconnect_msg[128];
    snprintf(disconnect_msg, sizeof(disconnect_msg), "%s disconnected (clients: %d/%d, frames: %lu)",
             stream_name, remaining, max_clients, frame_count);
    send_udp_log("INFO", disconnect_msg);
    
    return res;
}

// Handler: MJPEG stream (port 81, /stream)
// Full-speed stream for web dashboard — sends frames as fast as captureTask produces them.
// Separate client counter from detection stream so GUI and Python don't steal each other's slots.
static esp_err_t stream_handler(httpd_req_t *req) {
    return generic_video_stream_handler(req, &active_stream_clients, MAX_STREAM_CLIENTS, "GUI Stream", false);
}

// Handler: Rate-limited MJPEG stream (port 81, /detection-stream)
// Capped at ~30 FPS (33ms delay) to avoid overwhelming Python clients (A12_System).
// Full CORS headers for cross-origin fetch. Same ring buffer, separate client counter.
static esp_err_t detection_stream_handler(httpd_req_t *req) {
    return generic_video_stream_handler(req, &active_detection_clients, MAX_DETECTION_CLIENTS, "Detection stream", true);
}

static esp_err_t status_handler(httpd_req_t *req) {
    // Increase buffer size to prevent truncation (person detection fields added)
    char json_response[2560];

    String ip = WiFi.localIP().toString();
    if (WiFi.getMode() == WIFI_AP) {
        ip = WiFi.softAPIP().toString();
    }

    size_t max_alloc_heap = ESP.getMaxAllocHeap();
    int total_clients = active_stream_clients + active_detection_clients;
    
    // Uptime formatting
    unsigned long uptime_sec = (unsigned long)(esp_timer_get_time() / 1000000);
    unsigned long uptime_days = uptime_sec / 86400;
    unsigned long uptime_hours = (uptime_sec % 86400) / 3600;
    unsigned long uptime_mins = (uptime_sec % 3600) / 60;
    
    // Flash info
    uint32_t flash_size = ESP.getFlashChipSize();
    uint32_t flash_used = ESP.getSketchSize();

    // Acquire settings mutex for thread-safe config read
    if (settings_mutex) {
        xSemaphoreTake(settings_mutex, pdMS_TO_TICKS(100)); // 100ms timeout
    }

    // Get IR Config for Lux reading
    IRConfig irCfg = getIRConfig();

    sensor_t * s = esp_camera_sensor_get();
    if (s != NULL) {
        snprintf(json_response, sizeof(json_response),
            "{\"ip\":\"%s\",\"uptime\":\"%lud %luh %lum\",\"uptime_seconds\":%lu,\"uptime_days\":%lu,\"uptime_hours\":%lu,"
            "\"free_heap\":%u,\"max_alloc_heap\":%u,\"free_psram\":%u,"
            "\"flash_size\":%u,\"flash_used\":%u,\"flash_usage_pct\":%.1f,"
            "\"wifi_rssi\":%d,\"clients\":%d,\"stream_clients\":%d,\"detection_clients\":%d,"
            "\"vflip\":%d,\"hmirror\":%d,\"jpeg_quality\":%d,\"frame_size\":%d,"
            "\"brightness\":%d,\"contrast\":%d,\"saturation\":%d,\"sharpness\":%d,\"denoise\":%d,"
            "\"aec\":%d,\"ae_level\":%d,\"agc\":%d,\"awb\":%d,\"ambient_light_lux\":%.2f,\"ir_led\":%d,"
            "\"motion_telegram_photo\":%d,\"motion_telegram_video\":%d,\"motion_telegram_cooldown\":%d,"
            "\"motion_notify_start_hour\":%d,\"motion_notify_end_hour\":%d,"
            "\"person_detection_enabled\":%d,\"person_confidence_threshold\":%.2f,\"person_detection_cooldown\":%d,"
            "\"person_last_inference_ms\":%lu,\"sd_total_mb\":%llu,\"sd_used_mb\":%llu,\"version\":\"%s\"}",
            ip.c_str(),
            uptime_days, uptime_hours, uptime_mins,
            uptime_sec,
            uptime_days, uptime_hours,
            ESP.getFreeHeap(), max_alloc_heap, ESP.getFreePsram(),
            flash_size, flash_used, (float)flash_used/flash_size*100,
            WiFi.RSSI(), total_clients, active_stream_clients, active_detection_clients,
            s->status.vflip, s->status.hmirror, s->status.quality, s->status.framesize,
            s->status.brightness, s->status.contrast, s->status.saturation,
            s->status.sharpness, s->status.denoise,
            s->status.aec, s->status.ae_level, s->status.agc, s->status.awb,
            irCfg.last_lux_reading, irCfg.ir_led_current_state,
            config.motion_telegram_photo ? 1 : 0,
            config.motion_telegram_video ? 1 : 0,
            config.motion_telegram_cooldown,
            config.motion_notify_start_hour,
            config.motion_notify_end_hour,
            config.person_detection_enabled ? 1 : 0,
            config.person_confidence_threshold,
            config.person_detection_cooldown,
            personDetector.getLastResult().inference_ms,
            SD.cardSize() / (1024 * 1024),
            SD.usedBytes() / (1024 * 1024),
            config.version.c_str()
        );
    } else {
        snprintf(json_response, sizeof(json_response),
            "{\"ip\":\"%s\",\"uptime\":\"%lud %luh %lum\",\"uptime_seconds\":%lu,\"uptime_days\":%lu,\"uptime_hours\":%lu,"
            "\"free_heap\":%u,\"max_alloc_heap\":%u,\"free_psram\":%u,"
            "\"flash_size\":%u,\"flash_used\":%u,"
            "\"wifi_rssi\":%d,\"clients\":%d,\"error\":\"camera_sensor_null\"}",
            ip.c_str(),
            uptime_days, uptime_hours, uptime_mins,
            uptime_sec,
            uptime_days, uptime_hours,
            ESP.getFreeHeap(), max_alloc_heap, ESP.getFreePsram(),
            flash_size, flash_used,
            WiFi.RSSI(), total_clients
        );
    }

    // Release mutex
    if (settings_mutex) {
        xSemaphoreGive(settings_mutex);
    }

    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    httpd_resp_set_hdr(req, "Cache-Control", "no-store, no-cache, must-revalidate, max-age=0");
    httpd_resp_set_hdr(req, "Pragma", "no-cache");
    httpd_resp_set_hdr(req, "Connection", "close");
    
    return httpd_resp_send(req, json_response, HTTPD_RESP_USE_STRLEN);
}

// Handler: Settings HTML page
static esp_err_t settings_page_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "text/html");
    httpd_resp_set_hdr(req, "Content-Encoding", "gzip");
    return httpd_resp_send(req, (const char*)SETTINGS_HTML_GZ, SETTINGS_HTML_GZ_LEN);
}

// Handler: Settings page (GET) - Returns current camera settings as JSON
static esp_err_t settings_get_handler(httpd_req_t *req) {
    Serial.println("Settings GET handler called! Returning JSON.");
    
    // Acquire mutex for thread-safe config read
    if (settings_mutex) {
        xSemaphoreTake(settings_mutex, pdMS_TO_TICKS(100)); // 100ms timeout
    }

    sensor_t * s = esp_camera_sensor_get();
    // FIXED: Use StaticJsonDocument to avoid heap fragmentation
    StaticJsonDocument<1536> doc;

    if (s != NULL) {
        doc["jpeg_quality"] = s->status.quality;
        doc["frame_size"] = s->status.framesize;
        doc["vflip"] = s->status.vflip;
        doc["hmirror"] = s->status.hmirror;
        doc["brightness"] = s->status.brightness;
        doc["contrast"] = s->status.contrast;
        doc["saturation"] = s->status.saturation;
        doc["sharpness"] = s->status.sharpness;
        doc["denoise"] = s->status.denoise;
        doc["aec"] = s->status.aec;
        doc["ae_level"] = s->status.ae_level;
        doc["agc"] = s->status.agc;
        doc["awb"] = s->status.awb;
        doc["awb_gain"] = s->status.awb_gain;
        doc["wb_mode"] = s->status.wb_mode;
        doc["aec_value"] = s->status.aec_value;
        doc["gainceiling"] = s->status.gainceiling;
        doc["version"] = config.version.c_str(); // Add firmware version
    } else {
        doc["error"] = "Camera sensor unavailable";
    }

    // Motion → Telegram settings (always available, independent of camera sensor)
    doc["motion_telegram_photo"] = config.motion_telegram_photo;
    doc["motion_telegram_video"] = config.motion_telegram_video;
    doc["motion_telegram_cooldown"] = config.motion_telegram_cooldown;
    doc["motion_notify_start_hour"] = config.motion_notify_start_hour;
    doc["motion_notify_end_hour"] = config.motion_notify_end_hour;

    // Person Detection (AI FOMO) settings
    doc["person_detection_enabled"] = config.person_detection_enabled;
    doc["person_confidence_threshold"] = config.person_confidence_threshold;
    doc["person_detection_cooldown"] = config.person_detection_cooldown;

    // SD Card auto-recording settings
    doc["sd_auto_record"] = config.sd_auto_record;
    doc["sd_auto_record_duration"] = config.sd_auto_record_duration;
    doc["sd_max_usage_percent"] = config.sd_max_usage_percent;
    doc["sd_record_fps"] = config.sd_record_fps;

    // MQTT settings
    doc["mqtt_enabled"] = config.mqtt_enabled;
    doc["mqtt_server"] = config.mqtt_server;
    doc["mqtt_port"] = config.mqtt_port;

    // Release mutex
    if (settings_mutex) {
        xSemaphoreGive(settings_mutex);
    }

    String response;
    serializeJson(doc, response);

    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    return httpd_resp_sendstr(req, response.c_str());
}

// Handler: Settings update (POST)
static esp_err_t settings_post_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    Serial.println("Settings POST handler called!");

    // Allocate buffer on heap to save stack
    char* buf = (char*)malloc(1024);
    if (!buf) {
        Serial.println("ERROR: Failed to allocate buffer");
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }
    
    int ret, remaining = req->content_len;

    Serial.printf("Content length: %d bytes\n", remaining);

    // Buffer overflow protection
    if (remaining >= 1024) {
        Serial.println("ERROR: Request too large!");
        free(buf);
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }

    ret = httpd_req_recv(req, buf, remaining);
    if (ret <= 0) {
        Serial.printf("ERROR: Failed to receive data, ret=%d\n", ret);
        if (ret == HTTPD_SOCK_ERR_TIMEOUT) {
            httpd_resp_send_408(req);
        }
        free(buf);
        return ESP_FAIL;
    }
    buf[ret] = '\0';

    Serial.printf("Received JSON: %s\n", buf);

    // Acquire mutex before parsing and applying settings
    if (settings_mutex && xSemaphoreTake(settings_mutex, portMAX_DELAY) != pdTRUE) {
        Serial.println("ERROR: Failed to acquire settings mutex");
        free(buf);
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }

    // FIXED: Use StaticJsonDocument to avoid heap fragmentation
    StaticJsonDocument<2048> doc;
    // Cast to const char* to force copy (safer than Zero-Copy with mutable buffer)
    DeserializationError error = deserializeJson(doc, (const char*)buf);
    
    if (error) {
        Serial.printf("ERROR: JSON parse failed: %s\n", error.c_str());
        httpd_resp_set_status(req, "400 Bad Request");
        httpd_resp_set_type(req, "application/json");
        httpd_resp_send(req, "{\"success\":false,\"message\":\"Invalid JSON\"}", HTTPD_RESP_USE_STRLEN);
        xSemaphoreGive(settings_mutex);
        free(buf); // Free memory before return
        return ESP_OK;
    }

    // Reset watchdog before potentially blocking operations
    esp_task_wdt_reset(); // Keep WDT happy during stream processing
    
    // Apply settings
    sensor_t * s = esp_camera_sensor_get();
    if (s == NULL) {
        Serial.println("ERROR: Camera sensor is NULL! Cannot apply settings.");
        httpd_resp_set_status(req, "500 Internal Server Error");
        httpd_resp_set_type(req, "application/json");
        httpd_resp_send(req, "{\"success\":false,\"message\":\"Camera sensor unavailable\"}", HTTPD_RESP_USE_STRLEN);
        xSemaphoreGive(settings_mutex);
        free(buf); // Free memory before return
        return ESP_OK;
    }
    
    // Sensor is valid, proceed with settings
    Serial.println("Applying settings to camera sensor...");
        if (doc.containsKey("jpeg_quality")) {
            int quality = constrain((int)doc["jpeg_quality"], 5, 63);
            if (s->status.quality != quality) {
                s->set_quality(s, quality);
                config.jpeg_quality = quality;
            }
        }
        bool needs_reboot = false;
        if (doc.containsKey("frame_size")) {
            int framesize = doc["frame_size"];
            if (s->status.framesize != framesize) {
                // Framesize change requires DMA reconfig — save and reboot
                config.frame_size = framesize;
                needs_reboot = true;
            }
        }
        if (doc.containsKey("vflip")) {
            int vflip = doc["vflip"] ? 1 : 0;
            if (s->status.vflip != vflip) {
                s->set_vflip(s, vflip);
                config.flip_vertical = vflip;
            }
        }
        if (doc.containsKey("hmirror")) {
            int hmirror = doc["hmirror"] ? 1 : 0;
            if (s->status.hmirror != hmirror) {
                s->set_hmirror(s, hmirror);
                config.flip_horizontal = hmirror;
            }
        }
        // Obraz
        if (doc.containsKey("brightness")) {
            int val = doc["brightness"];
            if (s->status.brightness != val) s->set_brightness(s, val);
        }
        if (doc.containsKey("contrast")) {
            int val = doc["contrast"];
            if (s->status.contrast != val) s->set_contrast(s, val);
        }
        if (doc.containsKey("saturation")) {
            int val = doc["saturation"];
            if (s->status.saturation != val) s->set_saturation(s, val);
        }
        if (doc.containsKey("sharpness")) {
            int val = doc["sharpness"];
            if (s->status.sharpness != val) s->set_sharpness(s, val);
        }
        if (doc.containsKey("denoise")) {
            int val = doc["denoise"];
            if (s->status.denoise != val) s->set_denoise(s, val);
        }
        
        // Auto kontroly (use .as<int>() to correctly parse 0/1, not JsonVariant truthiness)
        if (doc.containsKey("aec")) {
            int val = doc["aec"].as<int>() ? 1 : 0;
            if (s->status.aec != val) s->set_exposure_ctrl(s, val);
        }
        if (doc.containsKey("aec2")) {
            int val = doc["aec2"].as<int>() ? 1 : 0;
            s->set_aec2(s, val);
        }
        if (doc.containsKey("ae_level")) {
            int val = doc["ae_level"];
            if (s->status.ae_level != val) s->set_ae_level(s, val);
        }
        if (doc.containsKey("agc")) {
            int val = doc["agc"].as<int>() ? 1 : 0;
            if (s->status.agc != val) s->set_gain_ctrl(s, val);
        }
        if (doc.containsKey("agc_gain")) {
            int val = doc["agc_gain"];
            if (s->status.agc_gain != val) s->set_agc_gain(s, val);
        }
        if (doc.containsKey("awb")) {
            int val = doc["awb"].as<int>() ? 1 : 0;
            if (s->status.awb != val) s->set_whitebal(s, val);
        }
        if (doc.containsKey("awb_gain")) {
            int val = doc["awb_gain"].as<int>() ? 1 : 0;
            if (s->status.awb_gain != val) s->set_awb_gain(s, val);
        }
        if (doc.containsKey("wb_mode")) {
            int val = doc["wb_mode"];
            if (s->status.wb_mode != val) s->set_wb_mode(s, val);
        }
        if (doc.containsKey("aec_value")) {
            int val = doc["aec_value"];
            if (s->status.aec_value != val) s->set_aec_value(s, val);
        }
        if (doc.containsKey("gainceiling")) {
            int val = doc["gainceiling"];
            if (s->status.gainceiling != val) s->set_gainceiling(s, (gainceiling_t)val);
        }

        // Motion → Telegram settings
        bool config_changed = false;
        if (doc.containsKey("motion_telegram_photo")) {
            bool val = doc["motion_telegram_photo"];
            if (config.motion_telegram_photo != val) {
                config.motion_telegram_photo = val;
                config_changed = true;
                Serial.printf("📷 Motion→Telegram foto: %s\n", val ? "ON" : "OFF");
            }
        }
        if (doc.containsKey("motion_telegram_video")) {
            bool val = doc["motion_telegram_video"];
            if (config.motion_telegram_video != val) {
                config.motion_telegram_video = val;
                config_changed = true;
                Serial.printf("🎬 Motion→Telegram video: %s\n", val ? "ON" : "OFF");
            }
        }
        if (doc.containsKey("motion_telegram_cooldown")) {
            int val = doc["motion_telegram_cooldown"];
            if (val >= 5 && val <= 3600 && config.motion_telegram_cooldown != val) {
                config.motion_telegram_cooldown = val;
                config_changed = true;
                Serial.printf("📷 Motion→Telegram cooldown: %ds\n", val);
            }
        }
        if (doc.containsKey("motion_notify_start_hour")) {
            int val = doc["motion_notify_start_hour"];
            if (val >= 0 && val <= 23 && config.motion_notify_start_hour != val) {
                config.motion_notify_start_hour = val;
                config_changed = true;
            }
        }
        if (doc.containsKey("motion_notify_end_hour")) {
            int val = doc["motion_notify_end_hour"];
            if (val >= 0 && val <= 23 && config.motion_notify_end_hour != val) {
                config.motion_notify_end_hour = val;
                config_changed = true;
            }
        }

        // Person Detection (AI FOMO) settings
        if (doc.containsKey("person_detection_enabled")) {
            bool val = doc["person_detection_enabled"];
            if (config.person_detection_enabled != val) {
                config.person_detection_enabled = val;
                config_changed = true;
                Serial.printf("🧠 Person detection: %s\n", val ? "ON" : "OFF");
            }
        }
        if (doc.containsKey("person_confidence_threshold")) {
            float val = doc["person_confidence_threshold"];
            if (val >= 0.1f && val <= 0.99f && config.person_confidence_threshold != val) {
                config.person_confidence_threshold = val;
                config_changed = true;
                Serial.printf("🧠 Person confidence threshold: %.0f%%\n", val * 100);
            }
        }
        if (doc.containsKey("person_detection_cooldown")) {
            int val = doc["person_detection_cooldown"];
            if (val >= 10 && val <= 3600 && config.person_detection_cooldown != val) {
                config.person_detection_cooldown = val;
                config_changed = true;
                Serial.printf("🧠 Person detection cooldown: %ds\n", val);
            }
        }

        // MQTT settings (non-credential parts)
        if (doc.containsKey("mqtt_enabled")) {
            bool val = doc["mqtt_enabled"];
            if (config.mqtt_enabled != val) {
                config.mqtt_enabled = val;
                config_changed = true;
                Serial.printf("MQTT: %s\n", val ? "ON" : "OFF");
            }
        }
        if (doc.containsKey("mqtt_server")) {
            String val = doc["mqtt_server"].as<String>();
            if (config.mqtt_server != val) {
                config.mqtt_server = val;
                config_changed = true;
            }
        }
        if (doc.containsKey("mqtt_port")) {
            int val = doc["mqtt_port"];
            if (val > 0 && val <= 65535 && config.mqtt_port != val) {
                config.mqtt_port = val;
                config_changed = true;
            }
        }

        // SD Card auto-recording settings
        if (doc.containsKey("sd_auto_record")) {
            bool val = doc["sd_auto_record"];
            if (config.sd_auto_record != val) {
                config.sd_auto_record = val;
                config_changed = true;
                Serial.printf("💾 SD auto-record: %s\n", val ? "ON" : "OFF");
            }
        }
        if (doc.containsKey("sd_auto_record_duration")) {
            int val = doc["sd_auto_record_duration"];
            if (val >= 5 && val <= 300 && config.sd_auto_record_duration != val) {
                config.sd_auto_record_duration = val;
                config_changed = true;
            }
        }
        if (doc.containsKey("sd_max_usage_percent")) {
            int val = doc["sd_max_usage_percent"];
            if (val >= 50 && val <= 99 && config.sd_max_usage_percent != val) {
                config.sd_max_usage_percent = val;
                config_changed = true;
            }
        }
        if (doc.containsKey("sd_record_fps")) {
            int val = doc["sd_record_fps"];
            if (val >= 1 && val <= 30 && config.sd_record_fps != val) {
                config.sd_record_fps = val;
                config_changed = true;
            }
        }

        if (config_changed) {
            saveConfig();
        }

        Serial.println("✅ Settings applied successfully!");

    httpd_resp_set_status(req, "200 OK");
    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    httpd_resp_set_hdr(req, "Connection", "close");
    if (needs_reboot) {
        httpd_resp_send(req, "{\"success\":true,\"message\":\"Settings updated. Resolution change requires reboot.\",\"needs_reboot\":true}", HTTPD_RESP_USE_STRLEN);
    } else {
        httpd_resp_send(req, "{\"success\":true,\"message\":\"Settings updated\"}", HTTPD_RESP_USE_STRLEN);
    }
    
    // Release mutex
    if (settings_mutex) xSemaphoreGive(settings_mutex);
    
    free(buf); // Free memory at the end

    if (needs_reboot) {
        saveConfig();  // Persist new framesize before reboot
        Serial.println("🔄 Framesize changed, auto-rebooting in 2s...");
        vTaskDelay(pdMS_TO_TICKS(2000));
        ESP.restart();
    }

    return ESP_OK;
}



// Handler for OPTIONS requests (CORS preflight)
static esp_err_t options_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_status(req, "204 No Content"); // No content, just headers
    httpd_resp_send(req, NULL, 0);
    return ESP_OK;
}

// IR Status handler - GET /ir-status
// Audio Status handler - GET /audio-status
static esp_err_t audio_status_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    char json[256];
    snprintf(json, sizeof(json),
             "{\"enabled\":%s,\"level\":%.1f,\"threshold\":%.1f,\"detected\":%s,\"sample_rate\":%d}",
             audio_enabled ? "true" : "false",
             current_audio_level,
             AUDIO_THRESHOLD_DB,
             (current_audio_level > AUDIO_THRESHOLD_DB) ? "true" : "false",
             I2S_SAMPLE_RATE);

    httpd_resp_send(req, json, strlen(json));
    return ESP_OK;
}

static esp_err_t stream_stats_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    // Acquire mutex for thread-safe read
    if (settings_mutex) {
        xSemaphoreTake(settings_mutex, pdMS_TO_TICKS(50));
    }

    sensor_t * s = esp_camera_sensor_get();
    int frame_size = s ? s->status.framesize : 0;
    int jpeg_quality = s ? s->status.quality : 0;

    char json[1024];
    snprintf(json, sizeof(json),
             "{\"max_stream_clients\":%d,\"max_detection_clients\":%d,"
             "\"active_stream_clients\":%d,\"active_detection_clients\":%d,"
             "\"total_clients\":%d,\"stream_fps\":%d,\"frame_size\":%d,"
             "\"jpeg_quality\":%d}",
             MAX_STREAM_CLIENTS,
             MAX_DETECTION_CLIENTS,
             active_stream_clients,
             active_detection_clients,
             active_stream_clients + active_detection_clients,
             15,  // Approximate FPS
             frame_size,
             jpeg_quality);

    // Release mutex
    if (settings_mutex) {
        xSemaphoreGive(settings_mutex);
    }

    httpd_resp_send(req, json, strlen(json));
    return ESP_OK;
}

// Motion Status handler - GET /motion-status
static esp_err_t motion_status_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    char json[128];
    snprintf(json, sizeof(json),
             "{\"motion_detected\":%s,\"score\":%d}",
             motionDetector.isMotionDetected() ? "true" : "false",
             motionDetector.getMotionScore());

    httpd_resp_send(req, json, strlen(json));
    return ESP_OK;
}

// ROI Mask handler - GET returns mask as "1100..." string, POST sets it
static esp_err_t roi_mask_get_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    int gw = motionDetector.getGridW();
    int gh = motionDetector.getGridH();

    // Build JSON: {"w":20,"h":15,"mask":"111011..."}
    String json = "{\"w\":" + String(gw) + ",\"h\":" + String(gh) + ",\"mask\":\"";
    for (int y = 0; y < gh; y++) {
        for (int x = 0; x < gw; x++) {
            json += motionDetector.getBlockMask(x, y) ? '1' : '0';
        }
    }
    json += "\"}";

    httpd_resp_send(req, json.c_str(), json.length());
    return ESP_OK;
}

static esp_err_t roi_mask_post_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;
    set_cors_headers(req);

    char content[512];
    size_t recv_size = (req->content_len < sizeof(content) - 1) ? req->content_len : sizeof(content) - 1;
    int ret = httpd_req_recv(req, content, recv_size);
    if (ret <= 0) { httpd_resp_send_408(req); return ESP_FAIL; }
    content[ret] = '\0';

    StaticJsonDocument<512> doc;
    if (deserializeJson(doc, content)) {
        httpd_resp_set_type(req, "application/json");
        httpd_resp_set_status(req, "400 Bad Request");
        httpd_resp_send(req, "{\"error\":\"Invalid JSON\"}", HTTPD_RESP_USE_STRLEN);
        return ESP_FAIL;
    }

    // Accept: {"mask":"111011..."} or {"clear":true}
    if (doc.containsKey("clear")) {
        motionDetector.clearMask();
        httpd_resp_send(req, "{\"ok\":true,\"action\":\"cleared\"}", HTTPD_RESP_USE_STRLEN);
        return ESP_OK;
    }

    const char* mask = doc["mask"];
    if (mask) {
        int gw = motionDetector.getGridW();
        int gh = motionDetector.getGridH();
        int len = strlen(mask);
        int i = 0;
        for (int y = 0; y < gh && i < len; y++) {
            for (int x = 0; x < gw && i < len; x++, i++) {
                motionDetector.setBlockMask(x, y, mask[i] != '0');
            }
        }
        int masked = 0;
        for (int j = 0; j < len; j++) if (mask[j] == '0') masked++;
        Serial.printf("ROI mask set: %d blocks masked out of %d\n", masked, gw * gh);
        httpd_resp_set_type(req, "application/json");
        char resp[64];
        snprintf(resp, sizeof(resp), "{\"ok\":true,\"masked\":%d,\"total\":%d}", masked, gw * gh);
        httpd_resp_send(req, resp, HTTPD_RESP_USE_STRLEN);
        return ESP_OK;
    }

    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_status(req, "400 Bad Request");
    httpd_resp_send(req, "{\"error\":\"need mask or clear\"}", HTTPD_RESP_USE_STRLEN);
    return ESP_FAIL;
}

// Motion Debug Endpoint -- returns full motion detection state + per-block motion grid
static esp_err_t motion_debug_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    int gw = motionDetector.getGridW();
    int gh = motionDetector.getGridH();

    // Build JSON response with motion state + block grid
    // Buffer: 2 grids of up to 64*48=3072 chars each + JSON overhead
    char* buf = (char*)malloc(8192);
    if (!buf) {
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }

    int len = snprintf(buf, 8192,
        "{\"detected\":%s,\"pct\":%.1f,\"score\":%d,\"brightness\":%d,"
        "\"threshold\":%d,\"night\":%s,"
        "\"grid_w\":%d,\"grid_h\":%d,\"motion\":\"",
        motionDetector.isMotionDetected() ? "true" : "false",
        motionDetector.getMotionPercent(),
        motionDetector.getMotionScore(),
        motionDetector.getAvgBrightness(),
        motionDetector.getEffectivePixelThreshold(),
        motionDetector.getAvgBrightness() < MOTION_NIGHT_BRIGHTNESS ? "true" : "false",
        gw, gh
    );

    // Append block motion grid as "010010..." string
    for (int y = 0; y < gh && len < 8000; y++) {
        for (int x = 0; x < gw && len < 8000; x++) {
            buf[len++] = motionDetector.getBlockMotion(x, y) ? '1' : '0';
        }
    }

    // Append ROI mask
    len += snprintf(buf + len, 8192 - len, "\",\"mask\":\"");
    for (int y = 0; y < gh && len < 8000; y++) {
        for (int x = 0; x < gw && len < 8000; x++) {
            buf[len++] = motionDetector.getBlockMask(x, y) ? '1' : '0';
        }
    }
    len += snprintf(buf + len, 8192 - len, "\"}");

    httpd_resp_send(req, buf, len);
    free(buf);
    return ESP_OK;
}

static esp_err_t ir_status_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    String jsonStatus = getIRStatusJSON();
    httpd_resp_send(req, jsonStatus.c_str(), jsonStatus.length());

    return ESP_OK;
}

// IR Control handler - POST /ir-control
static esp_err_t ir_control_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    set_cors_headers(req);

    // Read POST body
    char content[256];
    size_t recv_size = (req->content_len < sizeof(content) - 1) ? req->content_len : sizeof(content) - 1;

    int ret = httpd_req_recv(req, content, recv_size);
    if (ret <= 0) {
        if (ret == HTTPD_SOCK_ERR_TIMEOUT) {
            httpd_resp_send_408(req);
        }
        return ESP_FAIL;
    }
    content[ret] = '\0';

    // Parse JSON
    StaticJsonDocument<256> doc;
    DeserializationError error = deserializeJson(doc, content);

    if (error) {
        httpd_resp_set_status(req, "400 Bad Request");
        httpd_resp_send(req, "{\"error\":\"Invalid JSON\"}", HTTPD_RESP_USE_STRLEN);
        return ESP_FAIL;
    }

    // Get current config
    IRConfig irConfig = getIRConfig();

    // Update configuration
    if (doc.containsKey("state")) {
        String state = doc["state"].as<String>();
        if (state == "on") {
            irConfig.auto_mode = false;
            irConfig.manual_state = true;
        } else if (state == "off") {
            irConfig.auto_mode = false;
            irConfig.manual_state = false;
        } else if (state == "auto") {
            irConfig.auto_mode = true;
        }
    }

    if (doc.containsKey("threshold")) {
        float threshold = doc["threshold"];
        if (threshold >= MIN_LUX_THRESHOLD && threshold <= MAX_LUX_THRESHOLD) {
            irConfig.lux_threshold = threshold;
        }
    }

    if (doc.containsKey("auto_mode")) {
        irConfig.auto_mode = doc["auto_mode"];
    }

    if (doc.containsKey("time_based")) {
        irConfig.time_based = doc["time_based"];
    }

    if (doc.containsKey("night_start_hour")) {
        int hour = doc["night_start_hour"];
        if (hour >= 0 && hour < 24) {
            irConfig.night_start_hour = hour;
        }
    }

    if (doc.containsKey("night_end_hour")) {
        int hour = doc["night_end_hour"];
        if (hour >= 0 && hour < 24) {
            irConfig.night_end_hour = hour;
        }
    }
    
    if (doc.containsKey("lux_threshold")) {
        float threshold = doc["lux_threshold"];
        if (threshold >= 0) {
            irConfig.lux_threshold = threshold;
        }
    }

    // Apply new configuration
    setIRConfig(irConfig);

    // Return success with updated status
    httpd_resp_set_type(req, "application/json");
    String jsonStatus = getIRStatusJSON();
    httpd_resp_send(req, jsonStatus.c_str(), jsonStatus.length());

    return ESP_OK;
}

// RTSP Server Task - REMOVED (Library handles its own task)
// void rtspServerTask(void *parameter) { ... }

// Recording Task — AVI with interleaved MJPEG video + PCM16 audio
void recordingTask(void *parameter) {
    Serial.println("💾 Recording task started (AVI mode)");
    unsigned long my_last_timestamp = 0;
    unsigned long frame_write_count = 0;
    unsigned long lastFrameTime = 0;
    unsigned long recordingStartTime = 0;

    // Audio buffer on stack: 100ms of PCM16 mono @ 16kHz = 1600 samples = 3200 bytes
    const size_t AUDIO_SAMPLES_PER_FRAME = I2S_SAMPLE_RATE / 10; // 1600 at 16kHz/10fps
    int16_t audioBuf[AUDIO_SAMPLES_PER_FRAME];

    // PSRAM copy buffer: copy frame from ring buffer immediately, release slot,
    // then do slow SD write + I2S read from copy (prevents ring buffer starvation)
    uint8_t* frameCopy = (uint8_t*)ps_malloc(FRAME_BUFFER_SLOT_SIZE);
    if (!frameCopy) {
        Serial.println("❌ Recording task: failed to allocate PSRAM copy buffer!");
        vTaskDelete(NULL);
        return;
    }

    while(true) {
        if (is_recording) {

            // Frame decimation: only record at configured fps
            unsigned long now = millis();
            unsigned long frameInterval = 1000 / config.sd_record_fps;
            if (now - lastFrameTime < frameInterval) {
                vTaskDelay(pdMS_TO_TICKS(5));
                continue;
            }

            // Track recording start for auto-stop
            if (frame_write_count == 0) {
                recordingStartTime = now;
            }

            // Auto-stop: 45MB file size or 120s duration
            if (recordingFile) {
                size_t fileSize = recordingFile.position();
                if (fileSize > 45 * 1024 * 1024 || (now - recordingStartTime > 120000)) {
                    Serial.printf("💾 AVI auto-stop: %uKB, %lus\n",
                        (unsigned)(fileSize / 1024), (now - recordingStartTime) / 1000);
                    is_recording = false;
                    aviWriter.end();
                    recordingFile.close();
                    Serial.printf("💾 AVI finalized: %u video, %u audio chunks\n",
                        aviWriter.getVideoFrames(), aviWriter.getAudioChunks());
                    frame_write_count = 0;
                    continue;
                }
            }

            // Check for new frame in Ring Buffer — FAST copy-and-release
            size_t copiedLen = 0;
            if (current_frame_index >= 0) {
                int idx = current_frame_index;
                if (frameBuffers[idx].timestamp > my_last_timestamp) {
                    int rc = __atomic_load_n(&frameBuffers[idx].ref_count, __ATOMIC_SEQ_CST);
                    if (rc >= 0) {
                        __atomic_fetch_add(&frameBuffers[idx].ref_count, 1, __ATOMIC_SEQ_CST);

                        // FAST: Copy frame data and release ring buffer immediately
                        copiedLen = frameBuffers[idx].len;
                        if (copiedLen <= FRAME_BUFFER_SLOT_SIZE) {
                            memcpy(frameCopy, frameBuffers[idx].data, copiedLen);
                        } else {
                            copiedLen = 0; // Too large, skip
                        }
                        my_last_timestamp = frameBuffers[idx].timestamp;

                        __atomic_fetch_sub(&frameBuffers[idx].ref_count, 1, __ATOMIC_SEQ_CST);
                        // Ring buffer slot is now FREE for captureTask
                    }
                }
            }

            // SLOW: Write to SD + read audio (ring buffer already released)
            if (copiedLen > 0 && recordingFile) {
                if (!aviWriter.writeVideoFrame(frameCopy, copiedLen)) {
                    Serial.println("❌ AVI video write error!");
                }
                frame_write_count++;
                lastFrameTime = now;

                // Read and write interleaved audio chunk
                i2s_chan_handle_t rxh = getI2SRxHandle();
                if (rxh != NULL) {
                    size_t bytes_read = 0;
                    esp_err_t err = i2s_channel_read(rxh, audioBuf,
                        AUDIO_SAMPLES_PER_FRAME * sizeof(int16_t),
                        &bytes_read, pdMS_TO_TICKS(50));
                    if (err == ESP_OK && bytes_read > 0) {
                        aviWriter.writeAudioChunk(audioBuf, bytes_read);
                    }
                }
            }

            vTaskDelay(pdMS_TO_TICKS(5)); // Check frequently when recording
        } else {
            frame_write_count = 0;
            vTaskDelay(pdMS_TO_TICKS(500)); // Sleep if not recording
        }
    }
}

// Record Handler - POST /record {"action": "start"|"stop"}
static esp_err_t record_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    char content[100];
    size_t recv_size = (req->content_len < sizeof(content) - 1) ? req->content_len : sizeof(content) - 1;
    
    int ret = httpd_req_recv(req, content, recv_size);
    if (ret <= 0) {
        if (ret == HTTPD_SOCK_ERR_TIMEOUT) httpd_resp_send_408(req);
        return ESP_FAIL;
    }
    content[ret] = '\0';
    
    StaticJsonDocument<200> doc;
    DeserializationError error = deserializeJson(doc, content);
    
    if (error) {
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }
    
    const char* action = doc["action"];
    String msg = "";

    if (strcmp(action, "start") == 0) {
        if (is_recording) {
            msg = "Already recording";
        } else if (!SD.cardSize()) {
            msg = "No SD card";
        } else {
            // startSDRecording handles its own mutex
            if (startSDRecording()) {
                msg = String("Recording started: ") + lastRecordingFilename;
            } else {
                msg = "Failed to start recording";
            }
        }
    } else if (strcmp(action, "stop") == 0) {
        if (is_recording) {
            // stopSDRecording handles its own mutex
            stopSDRecording();
            msg = "Recording stopped";
        } else {
            msg = "Not recording";
        }
    } else {
        msg = "Invalid action";
    }
    
    httpd_resp_set_type(req, "application/json");
    String json = "{\"status\":\"" + msg + "\",\"recording\":" + (is_recording ? "true" : "false") + "}";
    httpd_resp_sendstr(req, json.c_str());
    return ESP_OK;
}

// Telemetry Handler - GET /telemetry
static esp_err_t telemetry_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    
    // FIXED: Use StaticJsonDocument to avoid heap fragmentation
    StaticJsonDocument<1024> doc;
    
    // System
    doc["uptime_seconds"] = millis() / 1000;
    doc["free_heap"] = ESP.getFreeHeap();
    doc["min_free_heap"] = ESP.getMinFreeHeap();
    doc["free_psram"] = ESP.getFreePsram();
    doc["cpu_freq_mhz"] = ESP.getCpuFreqMHz();
    
    // WiFi
    doc["wifi_rssi"] = WiFi.RSSI();
    doc["wifi_ip"] = WiFi.localIP().toString();
    doc["wifi_mac"] = WiFi.macAddress();
    doc["wifi_reconnects"] = wifi_health.reconnect_count;
    
    // Camera
    sensor_t * s = esp_camera_sensor_get();
    if (s) {
        doc["cam_width"] = s->status.framesize; // Need to map to pixels if needed
        doc["cam_quality"] = s->status.quality;
        doc["cam_fps_target"] = 30; // Hardcoded target
    }
    
    // Storage (SD Card)
    if(SD.cardSize()) {
        doc["sd_total_mb"] = SD.cardSize() / (1024 * 1024);
        doc["sd_used_mb"] = SD.usedBytes() / (1024 * 1024);
    } else {
        doc["sd_status"] = "not_mounted";
    }
    
    // Audio
    doc["audio_enabled"] = audio_enabled;
    doc["audio_level"] = current_audio_level;
    
    String response;
    serializeJson(doc, response);
    httpd_resp_sendstr(req, response.c_str());
    return ESP_OK;
}

static esp_err_t save_frame_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    // Check if SD card is mounted
    if(!SD.cardSize()) {
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }

    // Allocate buffer for filename
    char filepath[64];
    time_t now;
    struct tm timeinfo;
    time(&now);
    localtime_r(&now, &timeinfo);
    
    // Create filename based on timestamp
    // Note: If NTP is not synced, time will be from boot
    strftime(filepath, sizeof(filepath), "/%Y%m%d_%H%M%S.jpg", &timeinfo);
    
    // Check content length (limit to 500KB to be safe)
    if (req->content_len > 500 * 1024) {
        Serial.println("Frame too large");
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }
    
    // Allocate buffer
    char *buf = (char *)malloc(req->content_len);
    if (!buf) {
        Serial.println("Failed to allocate buffer");
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }
    
    // Receive data with retry limit
    int ret = 0;
    int remaining = req->content_len;
    int timeout_retries = 0;
    const int MAX_TIMEOUT_RETRIES = 10;
    while (remaining > 0) {
        int recved = httpd_req_recv(req, buf + ret, remaining);
        if (recved <= 0) {
            if (recved == HTTPD_SOCK_ERR_TIMEOUT) {
                timeout_retries++;
                if (timeout_retries >= MAX_TIMEOUT_RETRIES) {
                    Serial.println("❌ save_frame: Too many timeouts");
                    free(buf);
                    return ESP_FAIL;
                }
                continue;
            }
            free(buf);
            return ESP_FAIL;
        }
        timeout_retries = 0;  // Reset on successful read
        ret += recved;
        remaining -= recved;
    }
    
    // Write to SD card
    File file = SD.open(filepath, FILE_WRITE);
    if (!file) {
        Serial.println("Failed to open file for writing");
        free(buf);
        httpd_resp_send_500(req);
        return ESP_FAIL;
    }
    
    file.write((uint8_t*)buf, req->content_len);
    file.close();
    free(buf);
    
    Serial.printf("Saved frame to %s\n", filepath);
    httpd_resp_send(req, "Frame saved", HTTPD_RESP_USE_STRLEN);
    return ESP_OK;
}

// --- SD Card Auto-Recording Helpers ---
// Called from motionTask (camera_capture.cpp) to start/stop auto-recording

bool startSDRecording() {
    if (!SD.cardSize()) return false;
    if (!recordingMutex) return false;

    if (xSemaphoreTake(recordingMutex, pdMS_TO_TICKS(500)) != pdTRUE) return false;

    if (is_recording) {
        xSemaphoreGive(recordingMutex);
        return true; // Already recording
    }

    // Storage rotation: delete oldest files if SD is too full
    uint64_t total = SD.totalBytes();
    uint64_t used = SD.usedBytes();
    if (total > 0) {
        int usage_pct = (int)(used * 100 / total);
        if (usage_pct >= config.sd_max_usage_percent) {
            Serial.printf("💾 SD usage %d%% >= %d%%, rotating oldest files...\n",
                          usage_pct, config.sd_max_usage_percent);
            // Find and delete oldest file (by name — files use timestamps)
            int rotated = 0;
            while (usage_pct >= config.sd_max_usage_percent - 5 && rotated < 20) {
                File root = SD.open("/");
                if (!root) break;
                String oldest_name = "";
                File entry = root.openNextFile();
                while (entry) {
                    if (!entry.isDirectory()) {
                        String name = "/" + String(entry.name());
                        if (oldest_name.isEmpty() || name < oldest_name) {
                            oldest_name = name;
                        }
                    }
                    entry.close();
                    entry = root.openNextFile();
                }
                root.close();
                if (oldest_name.isEmpty()) break;
                size_t fsize = 0;
                File f = SD.open(oldest_name);
                if (f) { fsize = f.size(); f.close(); }
                if (SD.remove(oldest_name.c_str())) {
                    rotated++;
                    Serial.printf("  🗑️ Rotated: %s (%u KB)\n", oldest_name.c_str(), (unsigned)(fsize / 1024));
                } else {
                    break;
                }
                used = SD.usedBytes();
                usage_pct = (int)(used * 100 / total);
            }
            if (rotated > 0) {
                Serial.printf("  💾 Rotated %d files, now %d%% used\n", rotated, usage_pct);
            }
        }
    }

    // Generate filename with NTP timestamp
    char filename[64];
    time_t now;
    struct tm timeinfo;
    time(&now);
    localtime_r(&now, &timeinfo);
    strftime(filename, sizeof(filename), "/rec_%Y%m%d_%H%M%S.avi", &timeinfo);

    recordingFile = SD.open(filename, FILE_WRITE);
    if (recordingFile) {
        // Initialize AVI writer with current resolution and configured fps
        sensor_t* s = esp_camera_sensor_get();
        uint16_t w = 640, h = 480; // VGA default
        if (s) {
            // Map framesize to pixels (VGA=640x480 is the common recording resolution)
            switch (s->status.framesize) {
                case FRAMESIZE_QVGA: w = 320; h = 240; break;
                case FRAMESIZE_VGA:  w = 640; h = 480; break;
                case FRAMESIZE_SVGA: w = 800; h = 600; break;
                case FRAMESIZE_XGA:  w = 1024; h = 768; break;
                default: w = 640; h = 480; break;
            }
        }
        int fps = config.sd_record_fps > 0 ? config.sd_record_fps : 10;
        if (!aviWriter.begin(recordingFile, w, h, fps, I2S_SAMPLE_RATE)) {
            Serial.println("❌ AVI header write failed");
            recordingFile.close();
            xSemaphoreGive(recordingMutex);
            return false;
        }

        strncpy(lastRecordingFilename, filename, sizeof(lastRecordingFilename) - 1);
        lastRecordingFilename[sizeof(lastRecordingFilename) - 1] = '\0';
        is_recording = true;
        Serial.printf("💾 AVI recording started: %s (%dx%d @%dfps)\n", filename, w, h, fps);
        xSemaphoreGive(recordingMutex);
        return true;
    }

    Serial.println("❌ Auto-recording: failed to open file");
    xSemaphoreGive(recordingMutex);
    return false;
}

void stopSDRecording() {
    if (!recordingMutex) return;
    if (!is_recording) return;

    if (xSemaphoreTake(recordingMutex, pdMS_TO_TICKS(500)) == pdTRUE) {
        is_recording = false;
        xSemaphoreGive(recordingMutex);
        // Wait for recordingTask to finish its current write
        vTaskDelay(pdMS_TO_TICKS(200));
        if (xSemaphoreTake(recordingMutex, pdMS_TO_TICKS(2000)) == pdTRUE) {
            aviWriter.end();
            recordingFile.close();
            Serial.printf("💾 AVI recording stopped: %u frames, %u audio chunks\n",
                aviWriter.getVideoFrames(), aviWriter.getAudioChunks());
            xSemaphoreGive(recordingMutex);
        }
    }
}

// --- SD Download Handler ---
static esp_err_t sd_download_handler(httpd_req_t *req) {
    set_cors_headers(req);

    if (!SD.cardSize()) {
        httpd_resp_send_err(req, HTTPD_404_NOT_FOUND, "No SD card");
        return ESP_FAIL;
    }

    // Parse ?file= query parameter
    char query[128] = {0};
    char filepath[96] = {0};
    if (httpd_req_get_url_query_str(req, query, sizeof(query)) != ESP_OK) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "Missing ?file= parameter");
        return ESP_FAIL;
    }
    if (httpd_query_key_value(query, "file", filepath, sizeof(filepath)) != ESP_OK) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "Missing file parameter");
        return ESP_FAIL;
    }

    // Security: prevent path traversal
    if (strstr(filepath, "..") != NULL) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "Invalid path");
        return ESP_FAIL;
    }

    // Ensure path starts with /
    String path = filepath;
    if (!path.startsWith("/")) path = "/" + path;

    File file = SD.open(path, FILE_READ);
    if (!file || file.isDirectory()) {
        if (file) file.close();
        httpd_resp_send_err(req, HTTPD_404_NOT_FOUND, "File not found");
        return ESP_FAIL;
    }

    // Set content type based on extension
    if (path.endsWith(".jpg") || path.endsWith(".jpeg")) {
        httpd_resp_set_type(req, "image/jpeg");
    } else if (path.endsWith(".mjpeg")) {
        httpd_resp_set_type(req, "application/octet-stream");
    } else {
        httpd_resp_set_type(req, "application/octet-stream");
    }

    // Content-Disposition: attachment for download
    String disposition = "attachment; filename=\"" + path.substring(path.lastIndexOf('/') + 1) + "\"";
    httpd_resp_set_hdr(req, "Content-Disposition", disposition.c_str());

    // Stream file in 4KB chunks
    size_t total = file.size();
    char chunk[4096];
    size_t sent = 0;
    while (sent < total) {
        size_t to_read = (total - sent > sizeof(chunk)) ? sizeof(chunk) : (total - sent);
        size_t read = file.read((uint8_t*)chunk, to_read);
        if (read == 0) break;
        if (httpd_resp_send_chunk(req, chunk, read) != ESP_OK) {
            file.close();
            return ESP_FAIL;
        }
        sent += read;
        // Reset WDT for large files
        if (sent % (64 * 1024) == 0) esp_task_wdt_reset();
    }
    file.close();

    // End chunked response
    httpd_resp_send_chunk(req, NULL, 0);
    Serial.printf("💾 SD download: %s (%u KB)\n", path.c_str(), (unsigned)(total / 1024));
    return ESP_OK;
}

// Handler: SD Card — list files (GET) and clear all (POST)
static void deleteAllFiles(fs::FS &fs, const char *dirname, int &count) {
    // Loop until directory is empty (handles dirs with thousands of files)
    String dirStr = String(dirname);
    if (!dirStr.endsWith("/") && dirStr != "/") dirStr += "/";

    while (true) {
        File root = fs.open(dirname);
        if (!root || !root.isDirectory()) { root.close(); return; }

        File entry = root.openNextFile();
        if (!entry) { root.close(); return; } // Directory empty, done

        // Build full path: dirname + "/" + entry name
        // file.name() on ESP32 SD returns just the name (not full path)
        String name = String(entry.name());
        // Strip any leading path components — just keep the filename
        int lastSlash = name.lastIndexOf('/');
        if (lastSlash >= 0) name = name.substring(lastSlash + 1);
        String path = (dirStr == "/") ? "/" + name : dirStr + name;

        bool dir = entry.isDirectory();
        entry.close();
        root.close(); // Close dir before modifying (important for FAT)

        Serial.printf("  [%s] %s\n", dir ? "DIR" : "FILE", path.c_str());

        if (dir) {
            deleteAllFiles(fs, path.c_str(), count);
            if (!fs.rmdir(path.c_str())) {
                Serial.printf("  FAIL rmdir: %s (skipping)\n", path.c_str());
                return;
            }
        } else {
            if (fs.remove(path.c_str())) {
                count++;
                if (count % 200 == 0) Serial.printf("  🗑️ %d files deleted...\n", count);
            } else {
                Serial.printf("  FAIL rm: %s (skipping)\n", path.c_str());
                return;
            }
        }
    }
}

static esp_err_t sd_list_handler(httpd_req_t *req) {
    set_cors_headers(req);

    if (!SD.cardSize()) {
        httpd_resp_set_type(req, "application/json");
        httpd_resp_send(req, "{\"error\":\"no_sd_card\"}", HTTPD_RESP_USE_STRLEN);
        return ESP_OK;
    }

    File root = SD.open("/");
    if (!root) {
        httpd_resp_set_type(req, "application/json");
        httpd_resp_send(req, "{\"error\":\"cannot_open_root\"}", HTTPD_RESP_USE_STRLEN);
        return ESP_OK;
    }

    httpd_resp_set_type(req, "text/plain");

    String listing;
    File entry = root.openNextFile();
    int count = 0;
    while (entry && count < 200) {
        listing += entry.isDirectory() ? "[DIR] " : "";
        listing += String(entry.name());
        if (!entry.isDirectory()) {
            listing += " (" + String(entry.size() / 1024) + " KB)";
        }
        listing += "\n";
        entry.close();
        count++;
        entry = root.openNextFile();
    }
    root.close();

    if (listing.isEmpty()) listing = "(empty)\n";
    listing += "\nTotal: " + String(SD.usedBytes() / (1024*1024)) + " MB used / " +
               String(SD.totalBytes() / (1024*1024)) + " MB total\n";

    httpd_resp_send(req, listing.c_str(), HTTPD_RESP_USE_STRLEN);
    return ESP_OK;
}

static esp_err_t sd_clear_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    if (!SD.cardSize()) {
        httpd_resp_send(req, "{\"error\":\"no_sd_card\"}", HTTPD_RESP_USE_STRLEN);
        return ESP_OK;
    }

    Serial.println("🗑️ SD card clear requested...");
    uint64_t before = SD.usedBytes();
    int count = 0;
    deleteAllFiles(SD, "/", count);
    uint64_t after = SD.usedBytes();
    Serial.printf("🗑️ SD cleared: %d files, %llu MB freed\n", count, (before - after) / (1024 * 1024));

    char json[128];
    snprintf(json, sizeof(json), "{\"files_deleted\":%d,\"freed_mb\":%llu,\"remaining_mb\":%llu}",
             count, (before - after) / (1024 * 1024), after / (1024 * 1024));
    httpd_resp_send(req, json, HTTPD_RESP_USE_STRLEN);
    return ESP_OK;
}

// Handler: PSRAM Stats Endpoint (JSON)
static esp_err_t psram_stats_handler(httpd_req_t *req) {
    set_cors_headers(req);
    httpd_resp_set_type(req, "application/json");

    uint32_t psram_total = ESP.getPsramSize();
    uint32_t psram_free = ESP.getFreePsram();
    uint32_t psram_used = psram_total - psram_free;
    float usage_pct = (float)psram_used / psram_total * 100.0f;

    char json[256];
    snprintf(json, sizeof(json),
             "{\"total\":%u,\"free\":%u,\"used\":%u,\"usage_pct\":%.1f,"
             "\"total_mb\":%.2f,\"free_mb\":%.2f,\"used_mb\":%.2f}",
             psram_total,
             psram_free,
             psram_used,
             usage_pct,
             psram_total / 1024.0f / 1024.0f,
             psram_free / 1024.0f / 1024.0f,
             psram_used / 1024.0f / 1024.0f);

    httpd_resp_send(req, json, strlen(json));
    return ESP_OK;
}

// Init-time register readback (from main.cpp, stored before captureTask starts)
extern int initZone0_1;  // 0x5688 at init
extern int initZone8_9;  // 0x568c at init

// Handler: Health Check Endpoint (JSON)
// Debug: read OV3660 sensor registers (AEC, VTS, zone weights)
static esp_err_t reg_debug_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");

    sensor_t* s = esp_camera_sensor_get();
    if (!s) {
        httpd_resp_sendstr(req, "{\"error\":\"no sensor\"}");
        return ESP_OK;
    }

    char buf[768];
    snprintf(buf, sizeof(buf),
        "{\"init_zone_0_1\":\"0x%02X (want 0x11)\",\"init_zone_8_9\":\"0x%02X (want 0xEE)\","
        "\"aec_target_hi\":\"0x3a0f=%d\",\"aec_target_lo\":\"0x3a10=%d\","
        "\"aec_actual_hi\":\"0x3a1b=%d\",\"aec_actual_lo\":\"0x3a1e=%d\","
        "\"vts_hi\":\"0x380e=0x%02X\",\"vts_lo\":\"0x380f=0x%02X\","
        "\"zone_0_1_runtime\":\"0x5688=0x%02X\",\"zone_2_3_runtime\":\"0x5689=0x%02X\","
        "\"zone_8_9_runtime\":\"0x568c=0x%02X\",\"zone_14_15_runtime\":\"0x568f=0x%02X\","
        "\"exposure_hi\":\"0x3500=0x%02X\",\"exposure_mid\":\"0x3501=0x%02X\","
        "\"exposure_lo\":\"0x3502=0x%02X\","
        "\"gain\":\"0x350a=0x%02X,0x350b=0x%02X\","
        "\"aec_ctrl\":\"0x3503=0x%02X\"}",
        initZone0_1, initZone8_9,
        s->get_reg(s, 0x3a0f, 0xff), s->get_reg(s, 0x3a10, 0xff),
        s->get_reg(s, 0x3a1b, 0xff), s->get_reg(s, 0x3a1e, 0xff),
        s->get_reg(s, 0x380e, 0xff), s->get_reg(s, 0x380f, 0xff),
        s->get_reg(s, 0x5688, 0xff), s->get_reg(s, 0x5689, 0xff),
        s->get_reg(s, 0x568c, 0xff), s->get_reg(s, 0x568f, 0xff),
        s->get_reg(s, 0x3500, 0xff), s->get_reg(s, 0x3501, 0xff),
        s->get_reg(s, 0x3502, 0xff),
        s->get_reg(s, 0x350a, 0xff), s->get_reg(s, 0x350b, 0xff),
        s->get_reg(s, 0x3503, 0xff));

    httpd_resp_sendstr(req, buf);
    return ESP_OK;
}

static esp_err_t health_handler(httpd_req_t *req) {
    esp_task_wdt_reset(); // Keep WDT happy in detection stream
    
    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
    
    // FIXED: Use StaticJsonDocument to avoid heap fragmentation
    StaticJsonDocument<1024> doc;
    
    // Uptime
    unsigned long uptimeSeconds = millis() / 1000;
    doc["uptime_seconds"] = uptimeSeconds;
    doc["uptime_hours"] = (uptimeSeconds % 86400) / 3600;
    doc["uptime_days"] = uptimeSeconds / 86400;
    
    // Memory
    doc["free_heap"] = ESP.getFreeHeap();
    doc["free_psram"] = ESP.getFreePsram();
    doc["heap_health"] = ESP.getFreeHeap() > 50000 ? "healthy" : 
                        (ESP.getFreeHeap() > 30000 ? "warning" : "critical");
    
    // WiFi
    if (WiFi.status() == WL_CONNECTED) {
        doc["wifi_connected"] = true;
        doc["wifi_rssi"] = WiFi.RSSI();
        doc["wifi_quality"] = getWiFiQuality(WiFi.RSSI());
        doc["wifi_reconnects_1h"] = wifi_health.reconnect_count;
    } else {
        doc["wifi_connected"] = false;
        doc["wifi_quality"] = "disconnected";
    }
    
    // System Stats
    doc["total_restarts"] = sys_stats.total_restarts;
    doc["last_restart_reason"] = sys_stats.last_restart_reason;
    
    // Overall health status
    bool healthy = true;
    String issues = "";
    
    if (ESP.getFreeHeap() < 50000) {
        healthy = false;
        issues += "low_memory,";
    }
    if (WiFi.RSSI() < -75) {
        healthy = false;
        issues += "weak_wifi,";
    }
    if (wifi_health.reconnect_count > 3) {
        healthy = false;
        issues += "unstable_wifi,";
    }
    
    doc["overall_health"] = healthy ? "healthy" : "degraded";
    doc["issues"] = issues.length() > 0 ? issues.substring(0, issues.length()-1) : "none";
    doc["status"] = healthy ? "ok" : "warning";
    
    String response;
    serializeJson(doc, response);
    httpd_resp_sendstr(req, response.c_str());
    return ESP_OK;
}

// --- Captive Portal WiFi Setup ---
// Shown in AP mode when user connects and opens any URL
const char CAPTIVE_PORTAL_HTML[] PROGMEM = R"rawliteral(
<!DOCTYPE html>
<html lang="en">
<head>
    <meta charset="UTF-8">
    <title>ESP32 WiFi Setup</title>
    <meta name="viewport" content="width=device-width, initial-scale=1">
    <style>
        *{margin:0;padding:0;box-sizing:border-box}
        body{font-family:Arial,sans-serif;background:#1a1a2e;min-height:100vh;display:flex;justify-content:center;align-items:center;padding:20px}
        .card{background:#fff;border-radius:16px;box-shadow:0 10px 40px rgba(0,0,0,.4);max-width:400px;width:100%;overflow:hidden}
        .header{background:linear-gradient(135deg,#667eea,#764ba2);color:#fff;padding:24px;text-align:center}
        .header h1{font-size:1.4em;margin-bottom:6px}
        .header p{opacity:.85;font-size:.85em}
        .form{padding:24px}
        .field{margin-bottom:16px}
        .field label{display:block;margin-bottom:6px;font-weight:bold;color:#333;font-size:.9em}
        .field input{width:100%;padding:12px;border:2px solid #ddd;border-radius:8px;font-size:1em}
        .field input:focus{outline:none;border-color:#667eea}
        .btn{width:100%;padding:14px;border:none;border-radius:10px;font-size:1.1em;cursor:pointer;color:#fff;background:linear-gradient(135deg,#667eea,#764ba2);margin-top:8px}
        .btn:hover{transform:translateY(-1px);box-shadow:0 4px 12px rgba(0,0,0,.3)}
        .msg{padding:12px;border-radius:8px;margin-bottom:16px;display:none;text-align:center}
        .msg.ok{background:#d4edda;color:#155724;display:block}
        .msg.err{background:#f8d7da;color:#721c24;display:block}
        .scan{color:#667eea;cursor:pointer;font-size:.85em;text-decoration:underline;margin-bottom:12px;display:inline-block}
        #networks{margin-bottom:12px}
        #networks div{padding:8px 12px;background:#f5f5f5;border-radius:6px;margin:4px 0;cursor:pointer;font-size:.9em}
        #networks div:hover{background:#e0e0ff}
    </style>
</head>
<body>
    <div class="card">
        <div class="header">
            <h1>📷 ESP32-S3 AI Camera</h1>
            <p>WiFi setup</p>
        </div>
        <div class="form">
            <div id="status" class="msg"></div>
            <span class="scan" onclick="scanNetworks()">🔍 Scan WiFi networks</span>
            <div id="networks"></div>
            <form id="wifiForm" onsubmit="return submitForm(event)">
                <div class="field">
                    <label for="ssid">WiFi SSID</label>
                    <input type="text" id="ssid" name="ssid" required placeholder="WiFi network name">
                </div>
                <div class="field">
                    <label for="pass">WiFi password</label>
                    <input type="password" id="pass" name="pass" placeholder="Password">
                </div>
                <button type="submit" class="btn">📡 Connect</button>
            </form>
        </div>
    </div>
    <script>
        function scanNetworks(){
            document.getElementById('networks').innerHTML='<div>Scanning...</div>';
            fetch('/wifi-scan').then(r=>r.json()).then(data=>{
                var h='';
                data.forEach(n=>{h+='<div onclick="document.getElementById(\'ssid\').value=\''+n.ssid+'\'">'+n.ssid+' ('+n.rssi+' dBm)</div>'});
                document.getElementById('networks').innerHTML=h||'<div>No networks found</div>';
            }).catch(()=>{document.getElementById('networks').innerHTML='<div>Scan failed</div>'});
        }
        function submitForm(e){
            e.preventDefault();
            var s=document.getElementById('status');
            s.className='msg ok';s.textContent='Saving... ESP32 will restart.';s.style.display='block';
            fetch('/wifi-save',{method:'POST',headers:{'Content-Type':'application/json'},
                body:JSON.stringify({ssid:document.getElementById('ssid').value,password:document.getElementById('pass').value})
            }).then(r=>r.json()).then(()=>{
                s.textContent='Saved! ESP32 restarting in 3s...';
            }).catch(()=>{s.className='msg err';s.textContent='Save failed';});
            return false;
        }
    </script>
</body>
</html>
)rawliteral";

// Handler: Captive portal setup page
static esp_err_t captive_portal_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "text/html");
    return httpd_resp_send(req, CAPTIVE_PORTAL_HTML, HTTPD_RESP_USE_STRLEN);
}

// Handler: WiFi network scan
static esp_err_t wifi_scan_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");

    int n = WiFi.scanNetworks(false, false, false, 300);
    String json = "[";
    for (int i = 0; i < n && i < 15; i++) {
        if (i > 0) json += ",";
        json += "{\"ssid\":\"" + WiFi.SSID(i) + "\",\"rssi\":" + String(WiFi.RSSI(i)) + "}";
    }
    json += "]";
    WiFi.scanDelete();

    return httpd_resp_sendstr(req, json.c_str());
}

// Handler: Save WiFi credentials and reboot
static esp_err_t wifi_save_handler(httpd_req_t *req) {
    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");

    char buf[512];
    int received = httpd_req_recv(req, buf, sizeof(buf) - 1);
    if (received <= 0) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "No body");
        return ESP_FAIL;
    }
    buf[received] = '\0';

    StaticJsonDocument<256> doc;
    DeserializationError err = deserializeJson(doc, buf);
    if (err || !doc.containsKey("ssid")) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "Invalid JSON");
        return ESP_FAIL;
    }

    config.wifi_ssid = doc["ssid"].as<String>();
    config.wifi_password = doc["password"] | "";
    saveCredentialsToNVS();

    httpd_resp_sendstr(req, "{\"ok\":true}");
    Serial.printf("✅ WiFi credentials saved via captive portal: SSID=%s\n", config.wifi_ssid.c_str());

    // Delayed restart to let HTTP response complete
    vTaskDelay(pdMS_TO_TICKS(3000));
    ESP.restart();
    return ESP_OK;  // unreachable
}

// Handler: Redirect any unknown URL to captive portal (AP mode)
static esp_err_t captive_redirect_handler(httpd_req_t *req) {
    String url = "http://" + WiFi.softAPIP().toString() + "/setup";
    httpd_resp_set_status(req, "302 Found");
    httpd_resp_set_hdr(req, "Location", url.c_str());
    return httpd_resp_send(req, NULL, 0);
}

// --- Credentials Endpoint ---
// GET /credentials — returns masked overview (no passwords visible)
static esp_err_t credentials_get_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");

    StaticJsonDocument<512> doc;
    doc["wifi_ssid"] = config.wifi_ssid;
    doc["wifi_pass_set"] = config.wifi_password.length() > 0;
    doc["telegram_token_set"] = config.telegram_bot_token.length() > 0;
    doc["telegram_chat_id"] = config.telegram_chat_id;
    doc["http_user"] = config.http_user;
    doc["http_pass_set"] = config.http_pass.length() > 0;
    doc["ota_pass_set"] = config.ota_password.length() > 0;
    doc["ap_pass_set"] = config.ap_password.length() > 0;
    doc["mqtt_user"] = config.mqtt_user;
    doc["mqtt_pass_set"] = config.mqtt_pass.length() > 0;

    String response;
    serializeJson(doc, response);
    httpd_resp_sendstr(req, response.c_str());
    return ESP_OK;
}

// POST /credentials — update credentials and save to NVS
// Only fields present in JSON body are updated
static esp_err_t credentials_post_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    httpd_resp_set_type(req, "application/json");
    httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");

    char buf[1024];
    int received = httpd_req_recv(req, buf, sizeof(buf) - 1);
    if (received <= 0) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "No body");
        return ESP_FAIL;
    }
    buf[received] = '\0';

    StaticJsonDocument<1024> doc;
    DeserializationError err = deserializeJson(doc, buf);
    if (err) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "Invalid JSON");
        return ESP_FAIL;
    }

    bool restart_required = false;

    if (doc.containsKey("wifi_ssid")) {
        config.wifi_ssid = doc["wifi_ssid"].as<String>();
        restart_required = true;
    }
    if (doc.containsKey("wifi_password")) {
        config.wifi_password = doc["wifi_password"].as<String>();
        restart_required = true;
    }
    if (doc.containsKey("telegram_bot_token")) {
        config.telegram_bot_token = doc["telegram_bot_token"].as<String>();
    }
    if (doc.containsKey("telegram_chat_id")) {
        config.telegram_chat_id = doc["telegram_chat_id"].as<String>();
    }
    if (doc.containsKey("http_user")) {
        config.http_user = doc["http_user"].as<String>();
    }
    if (doc.containsKey("http_pass")) {
        config.http_pass = doc["http_pass"].as<String>();
    }
    if (doc.containsKey("ota_password")) {
        config.ota_password = doc["ota_password"].as<String>();
        restart_required = true;
    }
    if (doc.containsKey("ap_password")) {
        config.ap_password = doc["ap_password"].as<String>();
        restart_required = true;
    }
    if (doc.containsKey("mqtt_user")) {
        config.mqtt_user = doc["mqtt_user"].as<String>();
        restart_required = true;
    }
    if (doc.containsKey("mqtt_pass")) {
        config.mqtt_pass = doc["mqtt_pass"].as<String>();
        restart_required = true;
    }

    saveCredentialsToNVS();

    StaticJsonDocument<128> resp;
    resp["ok"] = true;
    resp["restart_required"] = restart_required;

    String response;
    serializeJson(resp, response);
    httpd_resp_sendstr(req, response.c_str());
    Serial.println("Credentials updated via /credentials POST");
    return ESP_OK;
}

// HTTP OTA Update handler — POST /update with raw firmware binary body
static esp_err_t ota_update_handler(httpd_req_t *req) {
    if (check_basic_auth(req) != ESP_OK) return ESP_FAIL;

    Serial.printf("OTA: Receiving firmware (%d bytes)...\n", req->content_len);

    if (req->content_len <= 0 || req->content_len > 6000000) {
        httpd_resp_send_err(req, HTTPD_400_BAD_REQUEST, "Invalid firmware size");
        return ESP_FAIL;
    }

    // Suspend camera capture to free memory and prevent crashes
    if (captureTaskHandle) {
        vTaskSuspend(captureTaskHandle);
        Serial.println("OTA: Camera capture suspended");
    }

    if (!Update.begin(req->content_len)) {
        Serial.printf("OTA: Update.begin failed: %s\n", Update.errorString());
        if (captureTaskHandle) vTaskResume(captureTaskHandle);
        httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "OTA begin failed");
        return ESP_FAIL;
    }

    // Read and write firmware in chunks
    char buf[4096];
    int remaining = req->content_len;
    int written = 0;

    while (remaining > 0) {
        int recv_len = httpd_req_recv(req, buf, (remaining < sizeof(buf)) ? remaining : sizeof(buf));
        if (recv_len <= 0) {
            if (recv_len == HTTPD_SOCK_ERR_TIMEOUT) continue;
            Serial.println("OTA: Receive error");
            Update.abort();
            if (captureTaskHandle) vTaskResume(captureTaskHandle);
            httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "Receive error");
            return ESP_FAIL;
        }

        if (Update.write((uint8_t*)buf, recv_len) != recv_len) {
            Serial.printf("OTA: Write error: %s\n", Update.errorString());
            Update.abort();
            if (captureTaskHandle) vTaskResume(captureTaskHandle);
            httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "Write error");
            return ESP_FAIL;
        }

        remaining -= recv_len;
        written += recv_len;

        // Progress every 10%
        if (written % (req->content_len / 10 + 1) < recv_len) {
            Serial.printf("OTA: %d%% (%d/%d bytes)\n", written * 100 / req->content_len, written, req->content_len);
            esp_task_wdt_reset();
        }
    }

    if (!Update.end(true)) {
        Serial.printf("OTA: Finalize error: %s\n", Update.errorString());
        if (captureTaskHandle) vTaskResume(captureTaskHandle);
        httpd_resp_send_err(req, HTTPD_500_INTERNAL_SERVER_ERROR, "OTA finalize failed");
        return ESP_FAIL;
    }

    Serial.println("OTA: Update successful! Rebooting...");
    httpd_resp_set_type(req, "application/json");
    httpd_resp_sendstr(req, "{\"ok\":true,\"message\":\"Update successful, rebooting...\"}");

    vTaskDelay(pdMS_TO_TICKS(500));
    ESP.restart();
    return ESP_OK;
}

// --- Handler registration helpers (reduce startCameraServer size) ---

// Helper: register GET + OPTIONS pair for an endpoint
static void registerGetEndpoint(httpd_handle_t server, const char* uri,
                                 esp_err_t (*handler)(httpd_req_t*)) {
    httpd_uri_t get_uri = { .uri = uri, .method = HTTP_GET, .handler = handler, .user_ctx = NULL };
    httpd_uri_t opt_uri = { .uri = uri, .method = HTTP_OPTIONS, .handler = options_handler, .user_ctx = NULL };
    httpd_register_uri_handler(server, &get_uri);
    httpd_register_uri_handler(server, &opt_uri);
}

// Helper: register POST + OPTIONS pair
static void registerPostEndpoint(httpd_handle_t server, const char* uri,
                                  esp_err_t (*handler)(httpd_req_t*)) {
    httpd_uri_t post_uri = { .uri = uri, .method = HTTP_POST, .handler = handler, .user_ctx = NULL };
    httpd_uri_t opt_uri = { .uri = uri, .method = HTTP_OPTIONS, .handler = options_handler, .user_ctx = NULL };
    httpd_register_uri_handler(server, &post_uri);
    httpd_register_uri_handler(server, &opt_uri);
}

// Helper: register GET + POST + OPTIONS triple
static void registerCrudEndpoint(httpd_handle_t server, const char* uri,
                                  esp_err_t (*get_handler)(httpd_req_t*),
                                  esp_err_t (*post_handler)(httpd_req_t*)) {
    httpd_uri_t get_uri = { .uri = uri, .method = HTTP_GET, .handler = get_handler, .user_ctx = NULL };
    httpd_uri_t post_uri = { .uri = uri, .method = HTTP_POST, .handler = post_handler, .user_ctx = NULL };
    httpd_uri_t opt_uri = { .uri = uri, .method = HTTP_OPTIONS, .handler = options_handler, .user_ctx = NULL };
    httpd_register_uri_handler(server, &get_uri);
    httpd_register_uri_handler(server, &post_uri);
    httpd_register_uri_handler(server, &opt_uri);
}

// Helper: register GET + OPTIONS + HEAD triple (for stream endpoints)
static void registerStreamEndpoint(httpd_handle_t server, const char* uri,
                                    esp_err_t (*handler)(httpd_req_t*),
                                    esp_err_t (*head_handler)(httpd_req_t*)) {
    httpd_uri_t get_uri = { .uri = uri, .method = HTTP_GET, .handler = handler, .user_ctx = NULL };
    httpd_uri_t opt_uri = { .uri = uri, .method = HTTP_OPTIONS, .handler = options_handler, .user_ctx = NULL };
    httpd_uri_t head_uri = { .uri = uri, .method = HTTP_HEAD, .handler = head_handler, .user_ctx = NULL };
    httpd_register_uri_handler(server, &get_uri);
    httpd_register_uri_handler(server, &opt_uri);
    httpd_register_uri_handler(server, &head_uri);
}

void startCameraServer() {
    // Initialize SD Card (SPI mode — DFRobot FireBeetle2 DFR1154)
    // CS pin must be HIGH before SPI init (DFRobot example pattern)
    pinMode(SD_CARD_CS, OUTPUT);
    digitalWrite(SD_CARD_CS, HIGH);
    SPI.begin(SD_CARD_SCK, SD_CARD_MISO, SD_CARD_MOSI);
    SPI.setFrequency(1000000);  // 1MHz for reliable init
    if(!SD.begin(SD_CARD_CS, SPI, 4000000)) {
        Serial.println("❌ SD Card Mount Failed at 4MHz, retrying 1MHz...");
        if(!SD.begin(SD_CARD_CS, SPI, 1000000)) {
            Serial.println("❌ SD Card Mount Failed (no card or wiring issue)");
        }
    }
    if(SD.cardType() != CARD_NONE && SD.cardSize() > 0) {
        Serial.printf("✅ SD Card Mounted: %llu MB\n", SD.cardSize() / (1024 * 1024));
    }

    httpd_config_t http_config = HTTPD_DEFAULT_CONFIG();
    http_config.server_port = 80;
    http_config.ctrl_port = 32768;
    http_config.max_open_sockets = 3;         // REDUCED to save sockets (was 7)
    http_config.lru_purge_enable = true;      // Auto-close oldest socket when limit reached
    http_config.stack_size = 20480;           // FIXED: Increased from 16KB to 20KB to prevent stack overflow
    http_config.max_uri_handlers = 64;        // 61 handlers (GET/POST/OPTIONS per endpoint) + reserve

    httpd_config_t stream_config = HTTPD_DEFAULT_CONFIG();
    stream_config.server_port = 81;
    stream_config.ctrl_port = 32769;
    stream_config.max_open_sockets = 2;       // REDUCED (was 4) - Only 2 active streams allowed
    stream_config.lru_purge_enable = true;
    stream_config.stack_size = 20480;         // FIXED: Increased from 16KB to 20KB to prevent stack overflow
    stream_config.max_uri_handlers = 10;

    httpd_config_t audio_config = HTTPD_DEFAULT_CONFIG();
    audio_config.server_port = 82;
    audio_config.ctrl_port = 32770;
    audio_config.max_open_sockets = 2;        // REDUCED (was 4)
    audio_config.lru_purge_enable = true;
    audio_config.stack_size = 8192;           // Audio handler is simpler
    audio_config.max_uri_handlers = 5;

    Serial.println("🔧 Configuring HTTP servers...");

    // Initialize UDP Mutex
    if (udp_mutex == NULL) {
        udp_mutex = xSemaphoreCreateMutex();
        if (udp_mutex == NULL) {
             Serial.println("❌ Failed to create UDP mutex!");
        } else {
             Serial.println("✅ UDP mutex created");
        }
    }

    // Initialize recording mutex
    if (recordingMutex == NULL) {
        recordingMutex = xSemaphoreCreateMutex();
        if (recordingMutex == NULL) {
            Serial.println("❌ Failed to create recording mutex!");
        } else {
            Serial.println("✅ Recording mutex created");
        }
    }

    // FIXED: Initialize settings mutex (thread-safe) - NO configASSERT to avoid restart!
    if (settings_mutex == NULL) {
        settings_mutex = xSemaphoreCreateMutex();
        if (settings_mutex == NULL) {
            Serial.println("❌ Failed to create settings mutex!");
            // Don't restart - better to continue without mutex than restart loop
        } else {
            Serial.println("✅ Settings mutex created");
        }
    }

    Serial.println("Starting camera web server (Port 80)...");

    if (httpd_start(&camera_httpd, &http_config) == ESP_OK) {
        // --- Core endpoints ---
        registerGetEndpoint(camera_httpd, "/", index_handler);
        registerGetEndpoint(camera_httpd, "/frame", frame_handler);
        registerGetEndpoint(camera_httpd, "/status", status_handler);
        registerGetEndpoint(camera_httpd, "/health", health_handler);
        registerGetEndpoint(camera_httpd, "/psram-stats", psram_stats_handler);
        registerGetEndpoint(camera_httpd, "/stream-stats", stream_stats_handler);
        registerGetEndpoint(camera_httpd, "/motion-status", motion_status_handler);

        // Telemetry & debug
        registerGetEndpoint(camera_httpd, "/reg-debug", reg_debug_handler);
        registerGetEndpoint(camera_httpd, "/telemetry", telemetry_handler);

        // --- Settings ---
        registerGetEndpoint(camera_httpd, "/settings-page", settings_page_handler);
        registerCrudEndpoint(camera_httpd, "/settings", settings_get_handler, settings_post_handler);

        // --- IR control ---
        registerGetEndpoint(camera_httpd, "/ir-status", ir_status_handler);
        registerPostEndpoint(camera_httpd, "/ir-control", ir_control_handler);

        // --- Audio ---
        registerGetEndpoint(camera_httpd, "/audio-status", audio_status_handler);

        // --- Credentials & OTA ---
        registerCrudEndpoint(camera_httpd, "/credentials", credentials_get_handler, credentials_post_handler);
        registerPostEndpoint(camera_httpd, "/update", ota_update_handler);

        // --- Record ---
        registerPostEndpoint(camera_httpd, "/record", record_handler);

        // --- Captive portal (AP mode) ---
        registerGetEndpoint(camera_httpd, "/setup", captive_portal_handler);
        registerGetEndpoint(camera_httpd, "/wifi-scan", wifi_scan_handler);
        registerPostEndpoint(camera_httpd, "/wifi-save", wifi_save_handler);

        // Captive portal redirects
        registerGetEndpoint(camera_httpd, "/generate_204", captive_redirect_handler);
        registerGetEndpoint(camera_httpd, "/hotspot-detect.html", captive_redirect_handler);

        // --- Media & SD endpoints ---
        registerPostEndpoint(camera_httpd, "/save_frame", save_frame_handler);
        registerCrudEndpoint(camera_httpd, "/roi-mask", roi_mask_get_handler, roi_mask_post_handler);
        registerGetEndpoint(camera_httpd, "/motion-debug", motion_debug_handler);

        // SD card management
        registerGetEndpoint(camera_httpd, "/sd-list", sd_list_handler);
        registerGetEndpoint(camera_httpd, "/sd-download", sd_download_handler);
        registerPostEndpoint(camera_httpd, "/sd-clear", sd_clear_handler);

        // Live log endpoints
        wsLogRegisterHandlers(camera_httpd);

        Serial.println("All HTTP handlers registered");

    // Start Stream Server (Port 81)
    Serial.println("Starting stream server (Port 81)...");
    if (httpd_start(&stream_httpd, &stream_config) == ESP_OK) {
        registerStreamEndpoint(stream_httpd, "/stream", stream_handler, stream_head_handler);
        registerStreamEndpoint(stream_httpd, "/detection-stream", detection_stream_handler, stream_head_handler);

        Serial.println("✅ Stream server started successfully");
    } else {
        Serial.println("❌ Failed to start stream server");
    }

#ifndef LITE_MODE_NO_RUNTIME_TASKS
    // Start Audio Server (Port 82)
    Serial.println("Starting audio server (Port 82)...");
    if (httpd_start(&audio_httpd, &audio_config) == ESP_OK) {
        registerGetEndpoint(audio_httpd, "/audio.wav", audioStreamHandler);
    }

    // Start RTSP Server
    Serial.println("Starting RTSP server...");
    if (rtspServer.init()) {
        Serial.printf("✅ RTSP server started at rtsp://%s:554/mjpeg/1\n", WiFi.localIP().toString().c_str());
    } else {
        Serial.println("❌ Failed to start RTSP server");
    }
#else
    Serial.println("⚡ LITE_MODE: audio_httpd:82 (~8KB) + RTSP (~16KB) skipped");
#endif

    // Start Central Camera Capture Task (feeds both RTSP and MJPEG)
    Serial.println("Starting Camera Capture Task...");
    startCameraCaptureTask();

        Serial.println("Camera web server started successfully");

#ifndef LITE_MODE_NO_RUNTIME_TASKS
        // Start Recording Task (AVI with audio — needs extra stack for PCM buffer)
        xTaskCreatePinnedToCore(
            recordingTask,     // Task function
            "Recording",       // Task name
            6144,              // Stack size (3.2KB audio buffer on stack)
            NULL,              // Parameters
            1,                 // Priority (Low)
            NULL,              // Task handle
            1                  // Core 1 (same as capture to avoid cache thrashing?) or 0
        );
        Serial.println("✅ Recording task queued");
#else
        Serial.println("⚡ LITE_MODE: recording task skipped (~6KB stack)");
#endif
    } else {
        Serial.println("Failed to start camera web server");
    }
}
